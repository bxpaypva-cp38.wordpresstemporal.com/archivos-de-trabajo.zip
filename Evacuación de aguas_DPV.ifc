Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\David Pajares\Dropbox\08_RECURSOS\CURSOS\0_CURSO MAMBA\Evacuación de aguas_DPV.ifc
Time: 2022-10-19T06:36:22
Made in: iMventa Ingenieros

# IfcProject
Phase: Obra nueva

# IfcSite, Emplazamiento
RefLatitude: 37, 4, 18, 728399; RefLongitude: -3, -37, -50, 545200; RefElevation: 783.023 m

# IfcBuilding, Edificio
ICAT-Informacio - ICAT_01-Projecte: Proyecto; ICAT_02-Emplaçament: Emplazamiento; ICAT_03-Equipament: Edificio; ICAT_04-Fase del projecte: Obra nova

# IfcBuildingStorey (3)
In: Edificio
Name | Elevation (m)
Planta Baja | 0
Planta Primera | 3.55
Elementos sin planta | -1.08406

# IfcBuildingElementProxy, Acometida_1
In: Planta Baja
Description: Acometida; Group: Mixtas
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: Acometida_1; TK_ETQ_Modelo: Acometida_1; TK_ETQ_Sistema: Mixtas
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 3.24304 m3/s; TK_PIPING_Caudal_simultáneo: 0.00590741 m3/s
ICAT-Identificacio - ICAT_04-Descripcio: Acometida_1; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcDistributionChamberElement (15)
In: Planta Baja
Description: Arqueta
ICAT-Identificacio - ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
Name | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Modelo = TK_ETQ_Dimensiones = ICAT-Tamany | TK_ETQ_Función | TK_ETQ_Sistema = Group | TK_ETQ_Diámetro_interior (m) | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s)
ARQ [118-110,108] | ARQ [118-110,108] | 40x40 | Arqueta de paso 3D | Pluvial | 100 | 0.00266704 | 0.00266704
ARQ [106-7,5] | ARQ [106-7,5] | 55x55 | Arqueta de paso 3D | Mixtas | 150 | 3.24304 | 0.00590741
ARQ [122-124] | ARQ [122-124] | 40x40 | Arqueta pie de bajante 3D | Pluvial | 100 | 0.00158231 | 0.00158231
ARQ [15-11,13] | ARQ [15-11,13] | 55x55 | Arqueta de paso 3D | Residual | 150 | 1.32288 | 0.00132288
ARQ [32-36,34] | ARQ [32-36,34] | 55x55 | Arqueta de paso 3D | Residual | 150 | 2.91548 | 0.00291548
ARQ [119-121] | ARQ [119-121] | 40x40 | Arqueta de paso 3D | Pluvial | 100 | 0.00158231 | 0.00158231
ARQ [23-10,8] | ARQ [23-10,8] | 55x55 | Arqueta de paso 3D | Residual | 150 | 3.24037 | 0.00324037
ARQ [86-88] | ARQ [86-88] | 55x55 | Arqueta pie de bajante 3D | Residual | 150 | 1.41421 | 0.00141421
ARQ [83-67,69] | ARQ [83-67,69] | 55x55 | Arqueta de paso 3D | Residual | 150 | 1.5 | 0.0015
ARQ [111-113] | ARQ [111-113] | 40x40 | Arqueta pie de bajante 3D | Pluvial | 100 | 0.00108472 | 0.00108472
ARQ [2-4] | ARQ [2-4] | 55x55 | Arqueta sifónica 3D | Mixtas | 150 | 3.24304 | 0.00590741
ARQ [37-85,39] | ARQ [37-85,39] | 55x55 | Arqueta de paso 3D | Residual | 150 | 2.78388 | 0.00278388
ARQ [24-26,31] | ARQ [24-26,31] | 55x55 | Arqueta de paso 3D | Residual | 150 | 2.95804 | 0.00295804
ARQ [40-66,42] | ARQ [40-66,42] | 55x55 | Arqueta pie de bajante 3D | Residual | 150 | 2.39792 | 0.00239792
ARQ [75-72,70] | ARQ [75-72,70] | 55x55 | Arqueta de paso 3D | Residual | 150 | 1.32288 | 0.00132288

# IfcDistributionPort (227)
Name | Group
173 x  | Residual
9 x  | Mixtas
45 x  | Pluvial

# IfcFlowFitting (4)
Description: Bote sifónico; Group: Residual
PSet_TeKton3D_Etiquetas - TK_ETQ_Sistema: Residual
ICAT-Identificacio - ICAT_05-EstatusObra: Obra nova
Name | In | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Modelo | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
BSIF [57-63,55,60] | Planta Primera | BSIF [57-63,55,60] | Policloruro de vinilo sanitario-SN1 | 1 | 0.001 | P.P. | Planta Primera | PSet_TeKton3D_Etiquetas - TK_ETQ_Dimensiones: ø32; ICAT-Geometria - ICAT-Tamany: ø32
BSIF [18-16,20] | Planta Baja | BSIF [18-16,20] | Bote sifónico ajustable | 0.866025 | 0.000866025 | P.B. | Planta Baja
BSIF [76-78,81] | Planta Baja | BSIF [76-78,81] | Bote sifónico ajustable | 0.866025 | 0.000866025 | P.B. | Planta Baja
BSIF [100-95,97,103] | Planta Primera | BSIF [100-95,97,103] | Policloruro de vinilo sanitario-SN1 | 1 | 0.001 | P.P. | Planta Primera | PSet_TeKton3D_Etiquetas - TK_ETQ_Dimensiones: ø32; ICAT-Geometria - ICAT-Tamany: ø32

# IfcFlowSegment: Policloruro de vinilo sanitario-SN1-ø110 (27)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: Policloruro de vinilo sanitario-SN1-ø110; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; InnerDiameter: 0.1056 m; OuterDiameter: 0.11 m
Name | In | Description | Material | Length (m) = TK_ETQ_Longitud (m) = ICAT-Longitud (m) | OuterSurfaceArea (m2) | NetCrossSectionArea (m2) | GrossCrossSectionArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Modelo | TK_ETQ_Dimensiones = ICAT-Tamany | TK_ETQ_Función | TK_ETQ_Sistema | TK_ETQ_Diámetro_interior (m) | TK_ETQ_Espesor (m) = ICAT-Gruix (m) | TK_ETQ_Pendiente | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT_03-Tipus | ICAT_05-EstatusObra | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio | Group
TUB [92-93] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.7 | 0.241903 | 0.00074506 | 0.00950332 | TUB [92-93] | Policloruro de vinilo sanitario-SN1 | ø110 | Ramal horizontal | Residual | 0.1056 | 0.0022 | -5729 | 1 | 0.001 | 1.34217 | 12.515 | 3.06567 | 3.75 | 12.515 | 3.06567 | 3.05 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [4-5] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.420968 | 0.145476 | 0.00074506 | 0.00950332 | TUB [4-5] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Mixtas | 0.1056 | 0.0022 | -2 | 3.24304 | 0.00590741 | 7.92876 | 4.6501 | -17.6846 | -0.847122 | 4.6251 | -18.1048 | -0.860065 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Mixtas
TUB [23-24] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 2.5703 | 0.888231 | 0.00074506 | 0.00950332 | TUB [23-24] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2 | 2.95804 | 0.00295804 | 3.9702 | 7.31162 | -15.3356 | -0.741692 | 5.0251 | -16.5096 | -0.795122 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [10-11] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 7.6617 | 2.6477 | 0.00074506 | 0.00950332 | TUB [10-11] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2.57831 | 1.32288 | 0.00132288 | 1.77553 | 0.889084 | -9.63962 | -0.0686047 | 4.2751 | -16.5096 | -0.268671 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [49-50] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 1.73424 | 0.59931 | 0.00074506 | 0.00950332 | TUB [49-50] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector colgante | Residual | 0.1056 | 0.0022 | -1 | 1.41421 | 0.00141421 | 1.89812 | 6.79643 | 2.88938 | 2.9 | 6.88662 | 4.62127 | 2.88266 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [50-51] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.075 | 0.0259181 | 0.00074506 | 0.00950332 | TUB [50-51] | Policloruro de vinilo sanitario-SN1 | ø110 | Bajante | Residual | 0.1056 | 0.0022 | -5729 | 1.41421 | 0.00141421 | 1.89812 | 6.79643 | 2.88938 | 2.97139 | 6.79643 | 2.88938 | 2.9 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [72-73] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.922835 | 0.318909 | 0.00074506 | 0.00950332 | TUB [72-73] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2 | 1 | 0.001 | 1.34217 | 0.625 | 6.2286 | -0.00880613 | 1.1353 | 6.99751 | -0.0272628 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [51-52] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.250218 | 0.0864692 | 0.00074506 | 0.00950332 | TUB [51-52] | Policloruro de vinilo sanitario-SN1 | ø110 | Ramal horizontal | Residual | 0.1056 | 0.0022 | -32.9326 | 1 | 0.001 | 1.34217 | 6.79501 | 2.65067 | 3.05 | 6.79643 | 2.88938 | 2.97139 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [73-74] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.208806 | 0.0721582 | 0.00074506 | 0.00950332 | TUB [73-74] | Policloruro de vinilo sanitario-SN1 | ø110 | Ramal horizontal | Residual | 0.1056 | 0.0022 | -348.01 | 1 | 0.001 | 1.34217 | 0.625 | 6.1686 | 0.2 | 0.625 | 6.2286 | -0.00880613 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [90-91] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.075 | 0.0259181 | 0.00074506 | 0.00950332 | TUB [90-91] | Policloruro de vinilo sanitario-SN1 | ø110 | Bajante | Residual | 0.1056 | 0.0022 | -5729 | 1.41421 | 0.00141421 | 1.89812 | 12.573 | 2.99163 | 2.95407 | 12.573 | 2.99163 | 2.9 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [91-92] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.120294 | 0.0415707 | 0.00074506 | 0.00950332 | TUB [91-92] | Policloruro de vinilo sanitario-SN1 | ø110 | Ramal horizontal | Residual | 0.1056 | 0.0022 | -101.994 | 1 | 0.001 | 1.34217 | 12.515 | 3.06567 | 3.05 | 12.573 | 2.99163 | 2.95407 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [69-70] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 4.01191 | 1.38642 | 0.00074506 | 0.00950332 | TUB [69-70] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2 | 1.32288 | 0.00132288 | 1.77553 | 1.8853 | 6.99751 | -0.0535714 | 5.89721 | 6.99751 | -0.13681 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [1-2] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.278291 | 0.0961703 | 0.00074506 | 0.00950332 | TUB [1-2] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Mixtas | 0.1056 | 0.0022 | -2 | 3.24304 | 0.00590741 | 7.92876 | 4.6251 | -18.8548 | -0.884065 | 4.6251 | -19.1331 | -0.889631 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Mixtas
TUB [7-8] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.05 | 0.0172788 | 0.00074506 | 0.00950332 | TUB [7-8] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2 | 3.24037 | 0.00324037 | 4.34914 | 4.6501 | -16.8846 | -0.819122 | 4.6501 | -16.9346 | -0.823122 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [88-89]-VP | Planta Baja |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | Residual
TUB [88-89] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 2.9 | 1.00217 | 0.00074506 | 0.00950332 | TUB [88-89] | Policloruro de vinilo sanitario-SN1 | ø110 | Bajante | Residual | 0.1056 | 0.0022 | -5729 | 1.41421 | 0.00141421 | 1.89812 | 15.505 | 0.124993 | 2.85899 | 15.505 | 0.124993 | 0 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [13-14] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.873686 | 0.301924 | 0.00074506 | 0.00950332 | TUB [13-14] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2 | 1 | 0.001 | 1.34217 | 1.54983 | -8.318 | 0 | 0.889084 | -8.88962 | -0.0195901 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [39-40] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 3.39778 | 1.17419 | 0.00074506 | 0.00950332 | TUB [39-40] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2.84921 | 2.39792 | 0.00239792 | 3.21842 | 7.32162 | 4.24627 | -0.283939 | 7.32162 | 0.849993 | -0.38498 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [31-32] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 8.53578 | 2.94975 | 0.00074506 | 0.00950332 | TUB [31-32] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2 | 2.91548 | 0.00291548 | 3.91307 | 7.31162 | -6.04983 | -0.543977 | 7.31162 | -14.5856 | -0.717692 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [42-43] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.1 | 0.0345575 | 0.00074506 | 0.00950332 | TUB [42-43] | Policloruro de vinilo sanitario-SN1 | ø110 | Bajante | Residual | 0.1056 | 0.0022 | -5729 | 1.87083 | 0.00187083 | 2.51098 | 6.88662 | 4.62127 | -0.0495961 | 6.88662 | 4.62127 | -0.1 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [52-53] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 0.7 | 0.241903 | 0.00074506 | 0.00950332 | TUB [52-53] | Policloruro de vinilo sanitario-SN1 | ø110 | Ramal horizontal | Residual | 0.1056 | 0.0022 | -5729 | 1 | 0.001 | 1.34217 | 6.79501 | 2.65067 | 3.75 | 6.79501 | 2.65067 | 3.05 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [89-90] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 4.10052 | 1.41704 | 0.00074506 | 0.00950332 | TUB [89-90] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector colgante | Residual | 0.1056 | 0.0022 | -1 | 1.41421 | 0.00141421 | 1.89812 | 12.573 | 2.99163 | 2.9 | 15.505 | 0.124993 | 2.85899 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.P. | Planta Primera | Residual
TUB [36-37] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 5.39983 | 1.86605 | 0.00074506 | 0.00950332 | TUB [36-37] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2 | 2.78388 | 0.00278388 | 3.73645 | 7.32162 | 0.0999927 | -0.40898 | 7.31162 | -5.29983 | -0.519977 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [66-67] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 2.11413 | 0.730592 | 0.00074506 | 0.00950332 | TUB [66-67] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -4.48954 | 1.5 | 0.0015 | 2.01326 | 6.64721 | 6.99751 | -0.16081 | 7.32162 | 4.99627 | -0.259909 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [43-49]-VP | Planta Baja |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | Residual
TUB [43-49] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 2.9 | 1.00217 | 0.00074506 | 0.00950332 | TUB [43-49] | Policloruro de vinilo sanitario-SN1 | ø110 | Bajante | Residual | 0.1056 | 0.0022 | -5729 | 1.41421 | 0.00141421 | 1.89812 | 6.88662 | 4.62127 | 2.88266 | 6.88662 | 4.62127 | -0.0495961 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual
TUB [85-86] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø110 | UNE EN 1 329-1:1999 | 7.43658 | 2.5699 | 0.00074506 | 0.00950332 | TUB [85-86] | Policloruro de vinilo sanitario-SN1 | ø110 | Colector enterrado | Residual | 0.1056 | 0.0022 | -2.62548 | 1.41421 | 0.00141421 | 1.89812 | 15.13 | 0.559993 | -0.011265 | 7.69662 | 0.474993 | -0.212334 | Policloruro de vinilo sanitario-SN1-ø110 | Obra nova | P.B. | Planta Baja | Residual

# IfcFlowSegment: Policloruro de vinilo sanitario-SN1-ø32 (13)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: Policloruro de vinilo sanitario-SN1-ø32; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; InnerDiameter: 0.0296 m; OuterDiameter: 0.032 m
Description: Tubería: Policloruro de vinilo sanitario-SN1-ø32; Material: UNE EN 1 329-1:1999; Group: Residual
BaseQuantities - NetCrossSectionArea: 0.000116113 m2; GrossCrossSectionArea: 0.000804248 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Modelo: Policloruro de vinilo sanitario-SN1; TK_ETQ_Dimensiones: ø32; TK_ETQ_Función: Ramal horizontal; TK_ETQ_Sistema: Residual; TK_ETQ_Diámetro_interior: 0.0296 m; TK_ETQ_Espesor: 0.0012 m
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.5 m3/s; TK_PIPING_Caudal_simultáneo: 0.0005 m3/s; TK_PIPING_Velocidad: 4.30614 m/s
ICAT-Identificacio - ICAT_03-Tipus: Policloruro de vinilo sanitario-SN1-ø32; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0012 m; ICAT-Tamany: ø32
Name | In | Length (m) = TK_ETQ_Longitud (m) = ICAT-Longitud (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Pendiente | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
TUB [58-59] | Planta Primera | 1.1 | 0.110584 | TUB [58-59] | -5729 | 6.8 | 4.3 | 4.15 | 6.8 | 4.3 | 3.05 | P.P. | Planta Primera
TUB [103-104] | Planta Primera | 2.15908 | 0.217055 | TUB [103-104] | -2 | 10.6 | 4.1 | 3.05 | 12.1458 | 2.59263 | 3.00682 | P.P. | Planta Primera
TUB [21-22] | Planta Baja | 0.6 | 0.0603186 | TUB [21-22] | -5729 | 1.54 | -7.5 | 0.6 | 1.54 | -7.5 | 0 | P.B. | Planta Baja
TUB [104-105] | Planta Primera | 1.1 | 0.110584 | TUB [104-105] | -5729 | 10.6 | 4.1 | 4.15 | 10.6 | 4.1 | 3.05 | P.P. | Planta Primera
TUB [101-102] | Planta Primera | 1.1 | 0.110584 | TUB [101-102] | -5729 | 10.6 | 3.1 | 4.15 | 10.6 | 3.1 | 3.05 | P.P. | Planta Primera
TUB [78-79] | Planta Baja | 0.259762 | 0.0261142 | TUB [78-79] | -2.00009 | 1.3 | 6.13499 | 0 | 1.04509 | 6.08507 | -0.00519525 | P.B. | Planta Baja
TUB [100-101] | Planta Primera | 1.61157 | 0.162013 | TUB [100-101] | -2 | 10.6 | 3.1 | 3.05 | 12.103 | 2.51858 | 3.01777 | P.P. | Planta Primera
TUB [79-80] | Planta Baja | 0.6 | 0.0603186 | TUB [79-80] | -5729 | 1.3 | 6.13499 | 0.6 | 1.3 | 6.13499 | 0 | P.B. | Planta Baja
TUB [61-62] | Planta Primera | 1.1 | 0.110584 | TUB [61-62] | -5729 | 6.8 | 3.5 | 4.15 | 6.8 | 3.5 | 3.05 | P.P. | Planta Primera
TUB [60-61] | Planta Primera | 0.578214 | 0.0581284 | TUB [60-61] | -2.00002 | 6.8 | 3.5 | 3.05 | 6.45642 | 3.03495 | 3.03844 | P.P. | Planta Primera
TUB [20-21] | Planta Baja | 1.06064 | 0.106628 | TUB [20-21] | -2.00001 | 1.54 | -7.5 | 0 | 1.68169 | -8.55113 | -0.0212129 | P.B. | Planta Baja
TUB [57-58] | Planta Primera | 1.30643 | 0.131337 | TUB [57-58] | -2 | 6.8 | 4.3 | 3.05 | 6.3761 | 3.06426 | 3.02387 | P.P. | Planta Primera
TUB [29-30] | Planta Baja | 0.251455 | 0.025279 | TUB [29-30] | -2 | 4.15433 | -13.2799 | 0 | 4.15433 | -13.5313 | -0.0050291 | P.B. | Planta Baja

# IfcFlowSegment: Policloruro de vinilo sanitario-SN1-ø40 (10)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: Policloruro de vinilo sanitario-SN1-ø40; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; InnerDiameter: 0.0376 m; OuterDiameter: 0.04 m
Description: Tubería: Policloruro de vinilo sanitario-SN1-ø40; Material: UNE EN 1 329-1:1999; Group: Residual
BaseQuantities - NetCrossSectionArea: 0.000146273 m2; GrossCrossSectionArea: 0.00125664 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Modelo: Policloruro de vinilo sanitario-SN1; TK_ETQ_Dimensiones: ø40; TK_ETQ_Función: Ramal horizontal; TK_ETQ_Sistema: Residual; TK_ETQ_Diámetro_interior: 0.0376 m; TK_ETQ_Espesor: 0.0012 m
ICAT-Identificacio - ICAT_03-Tipus: Policloruro de vinilo sanitario-SN1-ø40; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0012 m; ICAT-Tamany: ø40
Name | In | Length (m) = TK_ETQ_Longitud (m) = ICAT-Longitud (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Pendiente | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
TUB [45-46] | Planta Baja | 1.05873 | 0.133044 | TUB [45-46] | -2 | 0.866025 | 0.000866025 | 5.92063 | 4.61628 | 4.97996 | -0.00286484 | 5.67501 | 4.97996 | -0.0240394 | P.B. | Planta Baja
TUB [45-48] | Planta Baja | 0.143242 | 0.0180003 | TUB [45-48] | -16.7824 | 0.866025 | 0.000866025 | 5.92063 | 5.67501 | 4.83672 | 0 | 5.67501 | 4.97996 | -0.0240394 | P.B. | Planta Baja
TUB [34-35] | Planta Baja | 1.02079 | 0.128277 | TUB [34-35] | -20.3747 | 0.866025 | 0.000866025 | 5.92063 | 6.05306 | -5.20436 | 0 | 6.93662 | -5.67483 | -0.203953 | P.B. | Planta Baja
TUB [97-98] | Planta Primera | 1.72723 | 0.21705 | TUB [97-98] | -2 | 0.707107 | 0.000707107 | 4.83417 | 10.56 | 1.76 | 3.05 | 12.1458 | 2.44454 | 3.01546 | P.P. | Planta Primera
TUB [81-82] | Planta Baja | 0.445681 | 0.0560059 | TUB [81-82] | -2.00003 | 0.707107 | 0.000707107 | 4.83417 | 1.16414 | 5.59576 | 0 | 1.00234 | 6.01102 | -0.00891361 | P.B. | Planta Baja
TUB [64-65] | Planta Primera | 0.5 | 0.0628319 | TUB [64-65] | -5729 | 0.707107 | 0.000707107 | 4.83417 | 6.8 | 1.9 | 3.55 | 6.8 | 1.9 | 3.05 | P.P. | Planta Primera
TUB [98-99] | Planta Primera | 0.5 | 0.0628319 | TUB [98-99] | -5729 | 0.707107 | 0.000707107 | 4.83417 | 10.56 | 1.76 | 3.55 | 10.56 | 1.76 | 3.05 | P.P. | Planta Primera
TUB [18-19] | Planta Baja | 0.598636 | 0.0752268 | TUB [18-19] | -2.00002 | 0.707107 | 0.000707107 | 4.83417 | 1.54 | -9.28 | 0 | 1.68497 | -8.69919 | -0.0119727 | P.B. | Planta Baja
TUB [63-64] | Planta Primera | 1.07107 | 0.134595 | TUB [63-64] | -2.00001 | 0.707107 | 0.000707107 | 4.83417 | 6.8 | 1.9 | 3.05 | 6.40565 | 2.89583 | 3.02858 | P.P. | Planta Primera
TUB [46-47] | Planta Baja | 0.143242 | 0.0180003 | TUB [46-47] | -2 | 0.866025 | 0.000866025 | 5.92063 | 4.61628 | 4.83672 | 0 | 4.61628 | 4.97996 | -0.00286484 | P.B. | Planta Baja

# IfcFlowSegment: Policloruro de vinilo sanitario-SN1-ø50 (14)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: Policloruro de vinilo sanitario-SN1-ø50; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; InnerDiameter: 0.0476 m; OuterDiameter: 0.05 m
Name | In | Description | Material | Length (m) = TK_ETQ_Longitud (m) = ICAT-Longitud (m) | OuterSurfaceArea (m2) | NetCrossSectionArea (m2) | GrossCrossSectionArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Modelo | TK_ETQ_Dimensiones = ICAT-Tamany | TK_ETQ_Función | TK_ETQ_Sistema | TK_ETQ_Diámetro_interior (m) | TK_ETQ_Espesor (m) = ICAT-Gruix (m) | TK_ETQ_Pendiente | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT_03-Tipus | ICAT_05-EstatusObra | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio | Group
TUB [94-95] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.525339 | 0.08252 | 0.000183972 | 0.0019635 | TUB [94-95] | Policloruro de vinilo sanitario-SN1 | ø50 | Ramal horizontal | Residual | 0.0476 | 0.0012 | -2.00002 | 1 | 0.001 | 5.43562 | 12.2313 | 2.59263 | 2.99998 | 12.573 | 2.99163 | 2.98947 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.P. | Planta Primera | Residual
TUB [115-116]-VP | Planta Primera |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | Pluvial
TUB [115-116] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.1 | 0.015708 | 0.000183972 | 0.0019635 | TUB [115-116] | Policloruro de vinilo sanitario-SN1 | ø50 | Bajante | Pluvial | 0.0476 | 0.0012 | -5729 | 0.000552222 | 0.000552222 | 3.00167 | 5.355 | -9.72501 | 3.275 | 5.355 | -9.72501 | 3.17493 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.P. | Planta Primera | Pluvial
TUB [75-76] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.687574 | 0.108004 | 0.000183972 | 0.0019635 | TUB [75-76] | Policloruro de vinilo sanitario-SN1 | ø50 | Colector enterrado | Residual | 0.0476 | 0.0012 | -2.00001 | 0.866025 | 0.000866025 | 4.70738 | 1.00234 | 6.15911 | -0.0157537 | 1.5103 | 6.62251 | -0.0295714 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.B. | Planta Baja | Residual
TUB [51-54]-VP | Planta Primera |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | Residual
TUB [51-54] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.075 | 0.011781 | 0.000183972 | 0.0019635 | TUB [51-54] | Policloruro de vinilo sanitario-SN1 | ø50 | Bajante | Residual | 0.0476 | 0.0012 | -5729 | 1 | 0.001 | 5.43562 | 6.79643 | 2.88938 | 3.01041 | 6.79643 | 2.88938 | 2.97139 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.P. | Planta Primera | Residual
TUB [26-27] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 2.65807 | 0.417528 | 0.000183972 | 0.0019635 | TUB [26-27] | Policloruro de vinilo sanitario-SN1 | ø50 | Colector enterrado | Residual | 0.0476 | 0.0012 | -7.5671 | 0.5 | 0.0005 | 2.71781 | 4.45433 | -14.0313 | -0.0370291 | 6.93662 | -14.9606 | -0.237598 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.B. | Planta Baja | Residual
TUB [91-94]-VP | Planta Primera |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | Residual
TUB [91-94] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.075 | 0.011781 | 0.000183972 | 0.0019635 | TUB [91-94] | Policloruro de vinilo sanitario-SN1 | ø50 | Bajante | Residual | 0.0476 | 0.0012 | -5729 | 1 | 0.001 | 5.43562 | 12.573 | 2.99163 | 2.98947 | 12.573 | 2.99163 | 2.95407 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.P. | Planta Primera | Residual
TUB [43-44] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 1.00455 | 0.157795 | 0.000183972 | 0.0019635 | TUB [43-44] | Policloruro de vinilo sanitario-SN1 | ø50 | Ramal horizontal | Residual | 0.0476 | 0.0012 | -2 | 1.22474 | 0.00122474 | 6.65725 | 5.94829 | 4.97996 | -0.0295051 | 6.88662 | 4.62127 | -0.0495961 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.B. | Planta Baja | Residual
TUB [54-55] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.330986 | 0.0519912 | 0.000183972 | 0.0019635 | TUB [54-55] | Policloruro de vinilo sanitario-SN1 | ø50 | Ramal horizontal | Residual | 0.0476 | 0.0012 | -2.00006 | 1 | 0.001 | 5.43562 | 6.47119 | 2.95073 | 3.01703 | 6.79643 | 2.88938 | 3.01041 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.P. | Planta Primera | Residual
TUB [15-16] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.741252 | 0.116436 | 0.000183972 | 0.0019635 | TUB [15-16] | Policloruro de vinilo sanitario-SN1 | ø50 | Ramal horizontal | Residual | 0.0476 | 0.0012 | -2.00001 | 0.866025 | 0.000866025 | 4.70738 | 1.64059 | -8.62611 | -0.0280529 | 1.26408 | -9.26462 | -0.0446047 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.B. | Planta Baja | Residual
TUB [44-45] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 0.273284 | 0.0429273 | 0.000183972 | 0.0019635 | TUB [44-45] | Policloruro de vinilo sanitario-SN1 | ø50 | Ramal horizontal | Residual | 0.0476 | 0.0012 | -2 | 1.22474 | 0.00122474 | 6.65725 | 5.67501 | 4.97996 | -0.0240394 | 5.94829 | 4.97996 | -0.0295051 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.B. | Planta Baja | Residual
TUB [83-84] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø50 | UNE EN 1 329-1:1999 | 1.34368 | 0.211064 | 0.000183972 | 0.0019635 | TUB [83-84] | Policloruro de vinilo sanitario-SN1 | ø50 | Colector enterrado | Residual | 0.0476 | 0.0012 | -2 | 0.707107 | 0.000707107 | 3.84356 | 5.94829 | 5.31846 | 0 | 6.27221 | 6.62251 | -0.0280267 | Policloruro de vinilo sanitario-SN1-ø50 | Obra nova | P.B. | Planta Baja | Residual

# IfcFlowSegment: Policloruro de vinilo sanitario-SN1-ø90 (19)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: Policloruro de vinilo sanitario-SN1-ø90; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; InnerDiameter: 0.0868 m; OuterDiameter: 0.09 m
Group: Pluvial
Name | In | Description | Material | Length (m) = TK_ETQ_Longitud (m) = ICAT-Longitud (m) | OuterSurfaceArea (m2) | NetCrossSectionArea (m2) | GrossCrossSectionArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Modelo | TK_ETQ_Dimensiones = ICAT-Tamany | TK_ETQ_Función | TK_ETQ_Sistema | TK_ETQ_Diámetro_interior (m) | TK_ETQ_Espesor (m) = ICAT-Gruix (m) | TK_ETQ_Pendiente | TK_PIPING_Caudal_instalado (m3/s) = TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT_03-Tipus | ICAT_05-EstatusObra | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
TUB [115-117] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 2.66188 | 0.752629 | 0.000444347 | 0.00636173 | TUB [115-117] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector colgante | Pluvial | 0.0868 | 0.0016 | -3.76205 | 0.0005325 | 1.19839 | 2.695 | -9.72501 | 3.275 | 5.355 | -9.72501 | 3.17493 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera
TUB [126-127] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 6.00043 | 1.69658 | 0.000444347 | 0.00636173 | TUB [126-127] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector colgante | Pluvial | 0.0868 | 0.0016 | -1 | 0.000842139 | 1.89523 | 6.86501 | 4.70999 | 2.9 | 12.559 | 2.81683 | 2.84 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera
TUB [126-130]-VP | Planta Primera
TUB [126-130] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 4.15 | 1.17338 | 0.000444347 | 0.00636173 | TUB [126-130] | Policloruro de vinilo sanitario-SN1 | ø90 | Bajante | Pluvial | 0.0868 | 0.0016 | -5729 | 0.000740175 | 1.66576 | 12.559 | 2.81683 | 7.03891 | 12.559 | 2.81683 | 2.84 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera
TUB [130-131] | Elementos sin planta | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 1.10929 | 0.313645 | 0.000444347 | 0.00636173 | TUB [130-131] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector colgante | Pluvial | 0.0868 | 0.0016 | -1 | 0.000740175 | 1.66576 | 12 | 3.77499 | 7.05 | 12.559 | 2.81683 | 7.03891 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera
TUB [127-128]-VP | Planta Primera
TUB [127-128] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 4.15 | 1.17338 | 0.000444347 | 0.00636173 | TUB [127-128] | Policloruro de vinilo sanitario-SN1 | ø90 | Bajante | Pluvial | 0.0868 | 0.0016 | -5729 | 0.000842139 | 1.89523 | 6.86501 | 4.70999 | 7.03069 | 6.86501 | 4.70999 | 2.9 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera
TUB [113-114]-VP | Planta Baja
TUB [113-114] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 3.175 | 0.89771 | 0.000444347 | 0.00636173 | TUB [113-114] | Policloruro de vinilo sanitario-SN1 | ø90 | Bajante | Pluvial | 0.0868 | 0.0016 | -5729 | 0.00108472 | 2.44116 | 6.43346 | -10.0339 | 3.16371 | 6.43346 | -10.0339 | 0 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.B. | Planta Baja
TUB [106-107] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 4.13979 | 1.1705 | 0.000444347 | 0.00636173 | TUB [106-107] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector enterrado | Pluvial | 0.0868 | 0.0016 | -4.69509 | 0.00266704 | 6.00215 | 8.57569 | -15.1904 | -0.449597 | 5.0251 | -17.3096 | -0.649816 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.B. | Planta Baja
TUB [128-129] | Elementos sin planta | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 1.9314 | 0.546092 | 0.000444347 | 0.00636173 | TUB [128-129] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector colgante | Pluvial | 0.0868 | 0.0016 | -1 | 0.000842139 | 1.89523 | 5.17501 | 3.77499 | 7.05 | 6.86501 | 4.70999 | 7.03069 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera
TUB [114-115] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 1.12184 | 0.317193 | 0.000444347 | 0.00636173 | TUB [114-115] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector colgante | Pluvial | 0.0868 | 0.0016 | -1 | 0.00108472 | 2.44116 | 5.355 | -9.72501 | 3.17493 | 6.43346 | -10.0339 | 3.16371 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera
TUB [124-125]-VP | Planta Baja
TUB [124-125] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 2.9 | 0.819956 | 0.000444347 | 0.00636173 | TUB [124-125] | Policloruro de vinilo sanitario-SN1 | ø90 | Bajante | Pluvial | 0.0868 | 0.0016 | -5729 | 0.00158231 | 3.56099 | 15.42 | -0.100007 | 2.79914 | 15.42 | -0.100007 | 0 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.B. | Planta Baja
TUB [118-119] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 9.14 | 2.58427 | 0.000444347 | 0.00636173 | TUB [118-119] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector enterrado | Pluvial | 0.0868 | 0.0016 | -2 | 0.00158231 | 3.56099 | 8.645 | -0.943943 | -0.152658 | 8.645 | -10.0839 | -0.335458 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.B. | Planta Baja
TUB [110-111] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 1.61157 | 0.45566 | 0.000444347 | 0.00636173 | TUB [110-111] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector enterrado | Pluvial | 0.0868 | 0.0016 | -2 | 0.00108472 | 2.44116 | 6.73346 | -10.3939 | -0.011265 | 8.345 | -10.3839 | -0.0434964 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.B. | Planta Baja
TUB [107-108] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 4.50695 | 1.27431 | 0.000444347 | 0.00636173 | TUB [107-108] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector enterrado | Pluvial | 0.0868 | 0.0016 | -2 | 0.00266704 | 6.00215 | 8.645 | -10.6839 | -0.359458 | 8.57569 | -15.1904 | -0.449597 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.B. | Planta Baja
TUB [121-122] | Planta Baja | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 5.84038 | 1.65133 | 0.000444347 | 0.00636173 | TUB [121-122] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector enterrado | Pluvial | 0.0868 | 0.0016 | -2 | 0.00158231 | 3.56099 | 14.76 | -0.100007 | -0.01185 | 8.945 | -0.643943 | -0.128658 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.B. | Planta Baja
TUB [125-126] | Planta Primera | Tubería: Policloruro de vinilo sanitario-SN1-ø90 | UNE EN 1 329-1:1999 | 4.08576 | 1.15522 | 0.000444347 | 0.00636173 | TUB [125-126] | Policloruro de vinilo sanitario-SN1 | ø90 | Colector colgante | Pluvial | 0.0868 | 0.0016 | -1 | 0.00158231 | 3.56099 | 12.559 | 2.81683 | 2.84 | 15.42 | -0.100007 | 2.79914 | Policloruro de vinilo sanitario-SN1-ø90 | Obra nova | P.P. | Planta Primera

# IfcFlowTerminal (27)
ICAT-Identificacio - ICAT_05-EstatusObra: Obra nova
Name | In | Description | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Modelo | TK_ETQ_Sistema = Group | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
PB1_DUC | Planta Baja | UD Residual | PB1_DUC | Ducha | Residual | 0.707107 | 0.000707107 | P.B. | Planta Baja
PP4_LAV1 | Planta Primera | UD Residual | PP4_LAV1 | Lavabo | Residual | 0.5 | 0.0005 | P.P. | Planta Primera
PBCOC_LAV | Planta Baja | UD Residual | PBCOC_LAV | Lavavajillas doméstico | Residual | 0.866025 | 0.000866025 | P.B. | Planta Baja
PB2_LAV | Planta Baja | UD Residual | PB2_LAV | Lavabo | Residual | 0.5 | 0.0005 | P.B. | Planta Baja
PP3_INO | Planta Primera | UD Residual | PP3_INO | Inodoro con cisterna | Residual | 1 | 0.001 | P.P. | Planta Primera
PB1_INO | Planta Baja | UD Residual | PB1_INO | Inodoro con cisterna | Residual | 1 | 0.001 | P.B. | Planta Baja
PBEXT_DUC | Planta Baja | UD Residual | PBEXT_DUC | Ducha | Residual | 0.707107 | 0.000707107 | P.B. | Planta Baja
PP3_DUC | Planta Primera | UD Residual | PP3_DUC | Ducha | Residual | 0.707107 | 0.000707107 | P.P. | Planta Primera
UDP [116] | Planta Primera | UD Pluvial | UDP [116] | Arqueta sumidero toma central | Pluvial | 0.000552222 | 0.000552222 | P.P. | Planta Primera
PP3_LAV2 | Planta Primera | UD Residual | PP3_LAV2 | Lavabo | Residual | 0.5 | 0.0005 | P.P. | Planta Primera
PB_LAVADORA | Planta Baja | UD Residual | PB_LAVADORA | Lavadora doméstica | Residual | 0.866025 | 0.000866025 | P.B. | Planta Baja
PB2_DUC | Planta Baja | UD Residual | PB2_DUC | Ducha | Residual |  |  | P.B. | Planta Baja
PB1_LAV | Planta Baja | UD Residual | PB1_LAV | Lavabo | Residual | 0.5 | 0.0005 | P.B. | Planta Baja
UDP [131] | Elementos sin planta | UD Pluvial | UDP [131] | Sumidero azoteas no transitables | Pluvial | 0.000740175 | 0.000740175 | P.P. | Planta Primera
UDR [30] | Planta Baja | UD Residual | UDR [30] | Grifo garaje | Residual | 0.5 | 0.0005 | P.B. | Planta Baja
PB2_INO | Planta Baja | UD Residual | PB2_INO | Inodoro con cisterna | Residual | 1 | 0.001 | P.B. | Planta Baja
APA [26] | Planta Baja | UD Residual | APA [26] | Grifo aislado | Residual |  |  | P.B. | Planta Baja
UDP [129] | Elementos sin planta | UD Pluvial | UDP [129] | Sumidero azoteas no transitables | Pluvial | 0.000842139 | 0.000842139 | P.P. | Planta Primera
PP4_DUC | Planta Primera | UD Residual | PP4_DUC | Ducha | Residual | 0.707107 | 0.000707107 | P.P. | Planta Primera
UDR [82] | Planta Baja | UD Residual | UDR [82] | Ducha | Residual | 0.707107 | 0.000707107 | P.B. | Planta Baja
PP4_LAV2 | Planta Primera | UD Residual | PP4_LAV2 | Lavabo | Residual | 0.5 | 0.0005 | P.P. | Planta Primera
APA [145] | Planta Baja | UD Residual | APA [145] | Grifo garaje | Residual |  |  | P.B. | Planta Baja
UDP [117] | Planta Primera | UD Pluvial | UDP [117] | Arqueta sumidero toma central | Pluvial | 0.0005325 | 0.0005325 | P.P. | Planta Primera
PP3_LAV1 | Planta Primera | UD Residual | PP3_LAV1 | Lavabo | Residual | 0.5 | 0.0005 | P.P. | Planta Primera
PBCOC_FRE | Planta Baja | UD Residual | PBCOC_FRE | Fregadero doméstico | Residual | 0.866025 | 0.000866025 | P.B. | Planta Baja
PBEXT_PIS | Planta Baja | UD Residual | PBEXT_PIS | Grifo aislado | Residual |  |  | P.B. | Planta Baja
PP4_INO | Planta Primera | UD Residual | PP4_INO | Inodoro con cisterna | Residual | 1 | 0.001 | P.P. | Planta Primera

# IfcFlowTreatmentDevice, SGF [27-29]
In: Planta Baja
Description: Separador de grasas y fango; Group: Residual
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: SGF [27-29]; TK_ETQ_Modelo: Separador de grasas y fango; TK_ETQ_Sistema: Residual
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.5 m3/s; TK_PIPING_Caudal_simultáneo: 0.0005 m3/s
ICAT-Identificacio - ICAT_04-Descripcio: SGF [27-29]; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
