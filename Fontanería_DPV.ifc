Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowTerminal: Grifo-Grifo aislado (2)
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
Name | TK_ETQ_Nombre = ICAT_04-Descripcio
APA [26] | APA [26]
PBEXT_PIS | PBEXT_PIS

# IfcFlowTerminal: Grifo-Grifo garaje, APA [145]
In: Planta Baja
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Grifo-Grifo garaje; Status: New; Color: .NOTKNOWN.
Description: Aparato: Grifo-Grifo garaje; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: APA [145]; TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Grifo garaje; TK_ETQ_Modelo: Grifo garaje; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0002 m3/s; TK_PIPING_Caudal_simultáneo: 0.0002 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Grifo-Grifo garaje; ICAT_04-Descripcio: APA [145]; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowTerminal: Hidromezclador automático instalado-Ducha, PB2_DUC
In: Planta Baja
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Hidromezclador automático instalado-Ducha; Status: New; Color: .NOTKNOWN.
Description: Hidromezclador: Hidromezclador automático instalado-Ducha; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: PB2_DUC; TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Ducha; TK_ETQ_Modelo: Ducha; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0002 m3/s; TK_PIPING_Caudal_simultáneo: 0.0001 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Hidromezclador automático instalado-Ducha; ICAT_04-Descripcio: PB2_DUC; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowTerminal: Inodoro con cisterna-Inodoro con cisterna (4)
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Inodoro con cisterna-Inodoro con cisterna; Status: New; Color: .NOTKNOWN.
Description: Aparato: Inodoro con cisterna-Inodoro con cisterna; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Inodoro con cisterna; TK_ETQ_Modelo: Inodoro con cisterna; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0001 m3/s; TK_PIPING_Caudal_simultáneo: 0.0001 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Inodoro con cisterna-Inodoro con cisterna; ICAT_05-EstatusObra: Obra nova
Name | In | TK_ETQ_Nombre = ICAT_04-Descripcio | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
PP3_INO | Planta Primera | PP3_INO | P.P. | Planta Primera
PB1_INO | Planta Baja | PB1_INO | P.B. | Planta Baja
PB2_INO | Planta Baja | PB2_INO | P.B. | Planta Baja
PP4_INO | Planta Primera | PP4_INO | P.P. | Planta Primera

# IfcFlowTerminal: Lavabo sin pedestal-Lavabo (6)
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Lavabo sin pedestal-Lavabo; Status: New; Color: .NOTKNOWN.
Description: Hidromezclador: Lavabo sin pedestal-Lavabo; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Lavabo; TK_ETQ_Modelo: Lavabo; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0001 m3/s; TK_PIPING_Caudal_simultáneo: 0.000065 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Lavabo sin pedestal-Lavabo; ICAT_05-EstatusObra: Obra nova
Name | In | TK_ETQ_Nombre = ICAT_04-Descripcio | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
PP4_LAV1 | Planta Primera | PP4_LAV1 | P.P. | Planta Primera
PB2_LAV | Planta Baja | PB2_LAV | P.B. | Planta Baja
PP3_LAV2 | Planta Primera | PP3_LAV2 | P.P. | Planta Primera
PB1_LAV | Planta Baja | PB1_LAV | P.B. | Planta Baja
PP4_LAV2 | Planta Primera | PP4_LAV2 | P.P. | Planta Primera
PP3_LAV1 | Planta Primera | PP3_LAV1 | P.P. | Planta Primera

# IfcFlowTerminal: Lavadora doméstica-Lavadora doméstica, PB_LAVADORA
In: Planta Baja
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Lavadora doméstica-Lavadora doméstica; Status: New; Color: .NOTKNOWN.
Description: Hidromezclador: Lavadora doméstica-Lavadora doméstica; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: PB_LAVADORA; TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Lavadora doméstica; TK_ETQ_Modelo: Lavadora doméstica; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0002 m3/s; TK_PIPING_Caudal_simultáneo: 0.00015 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Lavadora doméstica-Lavadora doméstica; ICAT_04-Descripcio: PB_LAVADORA; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowTerminal: Lavavajillas doméstico-Lavavajillas doméstico, PBCOC_LAV
In: Planta Baja
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Lavavajillas doméstico-Lavavajillas doméstico; Status: New; Color: .NOTKNOWN.
Description: Hidromezclador: Lavavajillas doméstico-Lavavajillas doméstico; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: PBCOC_LAV; TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Lavavajillas doméstico; TK_ETQ_Modelo: Lavavajillas doméstico; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.00015 m3/s; TK_PIPING_Caudal_simultáneo: 0.0001 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Lavavajillas doméstico-Lavavajillas doméstico; ICAT_04-Descripcio: PBCOC_LAV; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
