Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\David Pajares\Dropbox\08_RECURSOS\CURSOS\0_CURSO MAMBA\Fontanería_DPV.ifc
Time: 2022-10-19T06:35:22
Made in: iMventa Ingenieros

# IfcProject
Phase: Obra nueva

# IfcSite, Emplazamiento
RefLatitude: 37, 4, 18, 728399; RefLongitude: -3, -37, -50, 545200; RefElevation: 783.023 m

# IfcBuilding, Edificio
ICAT-Informacio - ICAT_01-Projecte: Proyecto; ICAT_02-Emplaçament: Emplazamiento; ICAT_03-Equipament: Edificio; ICAT_04-Fase del projecte: Obra nova

# IfcBuildingStorey (2)
In: Edificio
Name | Elevation (m)
Planta Baja | 0
Planta Primera | 3.55

# IfcDistributionPort (372)
Name | Group
237 x  | Fontanería: Agua fría
135 x  | Fontanería: Agua caliente ida

# IfcEnergyConversionDevice: Calentador ACS-Calentador instantáneo, CAL [50-51]
In: Planta Baja
Type - ApplicableOccurrence: IfcBoiler
Type - Pset_BoilerTypeCommon - Reference: Calentador ACS-Calentador instantáneo; PressureRating: 0 Pa; OperatingMode: NOTKNOWN; HeatTransferSurfaceArea: 0 m2; NominalPartLoadRatio: 100 to 100; WaterInletTemperatureRange: 0 to 100 C; WaterStorageCapacity: 0; IsWaterStorageHeater: no; OutletTemperatureRange: 0 to 100 C; NominalEnergyConsumption: 0 W; EnergySource: NOTKNOWN
Description: Calentador ACS: Calentador ACS-Calentador instantáneo; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: CAL [50-51]; TK_ETQ_Modelo: Calentador instantáneo; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.00114 m3/s; TK_PIPING_Caudal_simultáneo: -0.000412629 m3/s; TK_PIPING_Velocidad: 1.25015 m/s
ICAT-Identificacio - ICAT_03-Tipus: Calentador ACS-Calentador instantáneo; ICAT_04-Descripcio: CAL [50-51]; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowController: Acometida
In: Planta Baja
Description: Suministro; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: Acometida; TK_ETQ_Modelo: Acometida; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.00419 m3/s; TK_PIPING_Caudal_simultáneo: -0.000921399 m3/s
ICAT-Identificacio - ICAT_04-Descripcio: Acometida; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowController: Asiento recta-DN20 (10)
Type - ApplicableOccurrence: IfcValveType; PredefinedType: STOPCOCK
Type - Pset_ValveTypeCommon - Reference: Asiento recta-DN20; Status: New; ValvePattern: STRAIGHT_2_PORT; ValveOperation: LEVER; ValveMechanism: BALL; Size: 0.02 m; TestPressure: 1469559 Pa; WorkingPressure: 1469559 Pa; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeIsolating - IsNormallyOpen: yes; IsolatingPurpose: Llave de corte de cuarto húmedo
Description: Válvula de corte: Asiento recta-DN20; Material: EN-806
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Válvulas Norma EN-806; TK_ETQ_Referencia: NAR; TK_ETQ_Material: EN-806; TK_ETQ_Modelo: Asiento recta; TK_ETQ_Dimensiones: DN20; TK_ETQ_Diámetro_interior: 0.02 m
ICAT-Identificacio - ICAT_03-Tipus: Asiento recta-DN20; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Tamany: DN20
Name | In | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Función | TK_ETQ_Sistema = Group | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
VCOR [175-176] | Planta Primera | VCOR [175-176] | Llave de corte de cuarto húmedo | Fontanería: Agua fría | 0.0005 | 0.000315963 | 1.00574 | 4293.32 | P.P. | Planta Primera
VCOR [60-61] | Planta Baja | VCOR [60-61] | Llave de corte de cuarto húmedo (ACS) | Fontanería: Agua caliente ida | 0.00015 | 0.00015 | 0.477465 | 967.619 | P.B. | Planta Baja
VCOR [66-67] | Planta Baja | VCOR [66-67] | Llave de corte de cuarto húmedo (ACS) | Fontanería: Agua caliente ida | 0.000165 | 0.000165 | 0.525211 | 1170.82 | P.B. | Planta Baja
VCOR [114-115] | Planta Baja | VCOR [114-115] | Llave de corte de cuarto húmedo (ACS) | Fontanería: Agua caliente ida | 0.000165 | 0.000165 | 0.525211 | 1170.82 | P.B. | Planta Baja
VCOR [28-29] | Planta Baja | VCOR [28-29] | Llave de corte de cuarto húmedo | Fontanería: Agua fría | 0.0002 | 0.0002 | 0.63662 | 1720.21 | P.B. | Planta Baja
VCOR [101-102] | Planta Primera | VCOR [101-102] | Llave de corte de cuarto húmedo (ACS) | Fontanería: Agua caliente ida | 0.00023 | 0.00017356 | 0.55246 | 1295.46 | P.P. | Planta Primera
VCOR [126-127] | Planta Baja | VCOR [126-127] | Llave de corte de cuarto húmedo | Fontanería: Agua fría | 0.0004 | 0.000301844 | 0.9608 | 3918.21 | P.B. | Planta Baja
VCOR [75-76] | Planta Baja | VCOR [75-76] | Llave de corte de cuarto húmedo (ACS) | Fontanería: Agua caliente ida | 0.0002 | 0.0002 | 0.63662 | 1720.21 | P.B. | Planta Baja
VCOR [158-159] | Planta Primera | VCOR [158-159] | Llave de corte de cuarto húmedo | Fontanería: Agua fría | 0.0005 | 0.000315963 | 1.00574 | 4293.32 | P.P. | Planta Primera
VCOR [89-90] | Planta Primera | VCOR [89-90] | Llave de corte de cuarto húmedo (ACS) | Fontanería: Agua caliente ida | 0.00023 | 0.00017356 | 0.55246 | 1295.46 | P.P. | Planta Primera

# IfcFlowController: Asiento recta-DN25 (2)
In: Planta Baja
Type - ApplicableOccurrence: IfcValveType; PredefinedType: STOPCOCK
Type - Pset_ValveTypeCommon - Reference: Asiento recta-DN25; Status: New; ValvePattern: STRAIGHT_2_PORT; ValveOperation: LEVER; ValveMechanism: BALL; Size: 0.025 m; TestPressure: 1469559 Pa; WorkingPressure: 1469559 Pa; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeIsolating - IsNormallyOpen: yes; IsolatingPurpose: Llave de corte de cuarto húmedo
Description: Válvula de corte: Asiento recta-DN25; Material: EN-806; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Válvulas Norma EN-806; TK_ETQ_Referencia: NAR; TK_ETQ_Material: EN-806; TK_ETQ_Modelo: Asiento recta; TK_ETQ_Dimensiones: DN25; TK_ETQ_Función: Llave de corte de cuarto húmedo; TK_ETQ_Sistema: Fontanería: Agua fría; TK_ETQ_Diámetro_interior: 0.025 m
ICAT-Identificacio - ICAT_03-Tipus: Asiento recta-DN25; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Tamany: DN25
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
Name | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa)
VCOR [9-10] | VCOR [9-10] | 0.00055 | 0.000347559 | 0.708041 | 1752.34
VCOR [34-35] | VCOR [34-35] | 0.00035 | 0.00035 | 0.713014 | 1777.04

# IfcFlowController: Colector N salidas (10)
PSet_TeKton3D_Etiquetas - TK_ETQ_Modelo: Colector N salidas
ICAT-Identificacio - ICAT_05-EstatusObra: Obra nova
Name | In | Description | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Dimensiones = ICAT_03-Tipus = ICAT-Tamany | TK_ETQ_Sistema = Group | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
Colector N salidas [68-68,69,72] | Planta Baja | Conexión: Ø13,1 | Colector N salidas [68-68,69,72] | Ø13,1 | Fontanería: Agua caliente ida | 0.000165 | 0.000065 | 0.48226 | P.B. | Planta Baja
Colector N salidas [116-116,117,121] | Planta Baja | Conexión: Ø13,1 | Colector N salidas [116-116,117,121] | Ø13,1 | Fontanería: Agua caliente ida | 0.000165 | 0.0001 | 0.741938 | P.B. | Planta Baja
Colector N salidas [91-91,92,95,98] | Planta Primera | Conexión: Ø13,1 | Colector N salidas [91-91,92,95,98] | Ø13,1 | Fontanería: Agua caliente ida | 0.00023 | 0.0000490497 | 0.363918 | P.P. | Planta Primera
Colector N salidas [103-103,104,107,110] | Planta Primera | Conexión: Ø13,1 | Colector N salidas [103-103,104,107,110] | Ø13,1 | Fontanería: Agua caliente ida | 0.00023 | 0.0000490497 | 0.363918 | P.P. | Planta Primera
Colector N salidas [128-128,129,132,136] | Planta Baja | Conexión: Ø16,4 | Colector N salidas [128-128,129,132,136] | Ø16,4 | Fontanería: Agua fría | 0.0004 | 0.000150922 | 0.714456 | P.B. | Planta Baja
Colector N salidas [77-77,78,81] | Planta Baja | Conexión: Ø13,1 | Colector N salidas [77-77,78,81] | Ø13,1 | Fontanería: Agua caliente ida | 0.0002 | 0.0001 | 0.741938 | P.B. | Planta Baja
Colector N salidas [36-36,37,41] | Planta Baja | Conexión: Ø20,5 | Colector N salidas [36-36,37,41] | Ø20,5 | Fontanería: Agua fría | 0.00035 | 0.0002 | 0.605944 | P.B. | Planta Baja
Colector N salidas [159-159,160,164,168,171] | Planta Primera | Conexión: Ø16,4 | Colector N salidas [159-159,160,164,168,171] | Ø16,4 | Fontanería: Agua fría | 0.0005 | 0.0000631925 | 0.299149 | P.P. | Planta Primera
Colector N salidas [11-11,12,16,19,23] | Planta Baja | Conexión: Ø20,5 | Colector N salidas [11-11,12,16,19,23] | Ø20,5 | Fontanería: Agua fría | 0.00055 | 0.0000631925 | 0.191456 | P.B. | Planta Baja
Colector N salidas [177-177,178,182,186,189] | Planta Primera | Conexión: Ø16,4 | Colector N salidas [177-177,178,182,186,189] | Ø16,4 | Fontanería: Agua fría | 0.0005 | 0.0000631925 | 0.299149 | P.P. | Planta Primera

# IfcFlowController: Compuerta-DN40, VCOR [6-7]
In: Planta Baja
Type - ApplicableOccurrence: IfcValveType; PredefinedType: STOPCOCK
Type - Pset_ValveTypeCommon - Reference: Compuerta-DN40; Status: New; ValvePattern: STRAIGHT_2_PORT; ValveOperation: LEVER; ValveMechanism: BALL; Size: 0.04 m; TestPressure: 1469559 Pa; WorkingPressure: 1469559 Pa; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeIsolating - IsNormallyOpen: yes; IsolatingPurpose: Llave de corte general a suministro
Description: Válvula de corte: Compuerta-DN40; Material: EN-806; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: VCOR [6-7]; TK_ETQ_Marca: Válvulas Norma EN-806; TK_ETQ_Referencia: NC; TK_ETQ_Material: EN-806; TK_ETQ_Modelo: Compuerta; TK_ETQ_Dimensiones: DN40; TK_ETQ_Función: Llave de corte general a suministro; TK_ETQ_Sistema: Fontanería: Agua fría; TK_ETQ_Diámetro_interior: 0.04 m
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.00419 m3/s; TK_PIPING_Caudal_simultáneo: 0.000921399 m3/s; TK_PIPING_Velocidad: 0.733226 m/s; TK_PIPING_Pérdida: 268.459 Pa
ICAT-Identificacio - ICAT_03-Tipus: Compuerta-DN40; ICAT_04-Descripcio: VCOR [6-7]; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Tamany: DN40
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowController: Escuadra-DN15, VCOR [144-145]
In: Planta Baja
Type - ApplicableOccurrence: IfcValveType; PredefinedType: STOPCOCK
Type - Pset_ValveTypeCommon - Reference: Escuadra-DN15; Status: New; ValvePattern: STRAIGHT_2_PORT; ValveOperation: LEVER; ValveMechanism: BALL; Size: 0.015 m; TestPressure: 1469559 Pa; WorkingPressure: 1469559 Pa; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeIsolating - IsNormallyOpen: yes; IsolatingPurpose: Llave de corte de entrada aparato
Description: Válvula de corte: Escuadra-DN15; Material: EN-806; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: VCOR [144-145]; TK_ETQ_Marca: Válvulas Norma EN-806; TK_ETQ_Referencia: NE; TK_ETQ_Material: EN-806; TK_ETQ_Modelo: Escuadra; TK_ETQ_Dimensiones: DN15; TK_ETQ_Función: Llave de corte de entrada aparato; TK_ETQ_Sistema: Fontanería: Agua fría; TK_ETQ_Diámetro_interior: 0.015 m
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0002 m3/s; TK_PIPING_Caudal_simultáneo: 0.0002 m3/s; TK_PIPING_Velocidad: 1.13177 m/s; TK_PIPING_Pérdida: 2558.46 Pa
ICAT-Identificacio - ICAT_03-Tipus: Escuadra-DN15; ICAT_04-Descripcio: VCOR [144-145]; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Tamany: DN15
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowController: Escuadra-DN25 (4)
In: Planta Baja
Type - ApplicableOccurrence: IfcValveType; PredefinedType: STOPCOCK
Type - Pset_ValveTypeCommon - Reference: Escuadra-DN25; Status: New; ValvePattern: STRAIGHT_2_PORT; ValveOperation: LEVER; ValveMechanism: BALL; Size: 0.025 m; TestPressure: 1469559 Pa; WorkingPressure: 1469559 Pa; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeIsolating - IsNormallyOpen: yes; IsolatingPurpose: Llave de corte de entrada aparato
Description: Válvula de corte: Escuadra-DN25; Material: EN-806
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Válvulas Norma EN-806; TK_ETQ_Referencia: NE; TK_ETQ_Material: EN-806; TK_ETQ_Modelo: Escuadra; TK_ETQ_Dimensiones: DN25; TK_ETQ_Diámetro_interior: 0.025 m
ICAT-Identificacio - ICAT_03-Tipus: Escuadra-DN25; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Tamany: DN25
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
Name | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Función | TK_ETQ_Sistema = Group | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa)
VCOR [150-151] | VCOR [150-151] | Llave de corte de entrada aparato | Fontanería: Agua fría | 0.0002 | 0.0002 | 0.407437 | 165.788
VCOR [147-148] | VCOR [147-148] | Llave de corte de entrada aparato | Fontanería: Agua fría | 0.00015 | 0.00015 | 0.305577 | 93.2557
VCOR [55-56] | VCOR [55-56] | Llave de corte de entrada aparato (ACS) | Fontanería: Agua caliente ida | 0.00114 | 0.000412629 | 0.840602 | 705.689
VCOR [46-47] | VCOR [46-47] | Llave de corte de entrada aparato | Fontanería: Agua fría | 0.00114 | 0.000412629 | 0.840602 | 705.689

# IfcFlowController: Estándar, CONT [2-3]
In: Planta Baja
Description: Contador; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: CONT [2-3]; TK_ETQ_Modelo: Estándar; TK_ETQ_Dimensiones: DN25; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.000972223 m3/s; TK_PIPING_Caudal_simultáneo: 0.000921399 m3/s; TK_PIPING_Velocidad: 8.14696 m/s; TK_PIPING_Presión: 4000.06 Pa; TK_PIPING_Pérdida: 3581.84 Pa
ICAT-Identificacio - ICAT_04-Descripcio: CONT [2-3]; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Tamany: DN25
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowSegment: PE-X Serie 5,0-ø16 (68)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: PE-X Serie 5,0-ø16; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; NominalDiameter: 0.017 m; InnerDiameter: 0.0131 m; OuterDiameter: 0.0161 m
Description: Tubería: PE-X Serie 5,0-ø16; Material: PE-X Serie 5,0
PSet_TeKton3D_Aislamiento - TK_AIS_Material: Estándar RITE; TK_AIS_Conductividad_térmica: 0.04; TK_AIS_Diámetro: 0.0161 m
BaseQuantities - NetCrossSectionArea: 0.0000688009 m2; GrossCrossSectionArea: 0.000203583 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Materiales plásticos; TK_ETQ_Referencia: PE-X Serie 5,0; TK_ETQ_Material: PE-X Serie 5,0; TK_ETQ_Modelo: PE-X Serie 5,0; TK_ETQ_Dimensiones: ø16; TK_ETQ_Diámetro_interior: 0.0131 m; TK_ETQ_Espesor: 0.0015 m
ICAT-Identificacio - ICAT_03-Tipus: PE-X Serie 5,0-ø16; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0015 m; ICAT-Tamany: ø16
Name | In | TK_AIS_Espesor_de_aislamiento (m) = TK_ETQ_Espesor_Aislamiento (m) | Length (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Función | TK_ETQ_Sistema = Group | TK_ETQ_Longitud (m) = ICAT-Longitud (m) | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa) | TK_PIPING_Pérdida_unitaria (Pa) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
TUB [132-133] | Planta Baja | 0.01 | 1.3552 | 0.0685457 | TUB [132-133] | Derivación a aparato | Fontanería: Agua fría | 1.232 | 0.0001 | 0.0001 | 0.741938 | 1222.22 | 793.646 | 1.4 | 6.13499 | 2.7 | 0.247244 | 5.70027 | 2.7 | P.B. | Planta Baja
TUB [12-13] | Planta Baja | 0.01 | 0.849611 | 0.042973 | TUB [12-13] | Derivación a aparato | Fontanería: Agua fría | 0.772373 | 0.0001 | 0.0001 | 0.741938 | 766.238 | 793.646 | 1.54 | -7.4 | 2.7 | 2.20883 | -7.0137 | 2.7 | P.B. | Planta Baja
TUB [179-180] | Planta Primera | 0.01 | 2.2 | 0.111275 | TUB [179-180] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.0001 | 0.0001 | 0.741938 | 1984.11 | 793.646 | 6.8 | 4.2 | 4.25 | 6.8 | 4.2 | 6.25 | P.P. | Planta Primera
TUB [78-79] | Planta Baja | 0.03 | 3.69362 | 0.186822 | TUB [78-79] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 3.35784 | 0.0001 | 0.0001 | 0.741938 | 3331.17 | 793.646 | 2.59791 | 2.08083 | 2.7 | 4.51628 | 4.83672 | 2.7 | P.B. | Planta Baja
TUB [115-116] | Planta Baja | 0.03 | 0.058876 | 0.00297793 | TUB [115-116] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.0535237 | 0.000165 | 0.000165 | 1.2242 | 126.446 | 1889.95 | 0.400961 | 5.30713 | 2.8 | 0.400961 | 5.36065 | 2.8 | P.B. | Planta Baja
TUB [151-152] | Planta Baja | 0.01 | 0.0617766 | 0.00312464 | TUB [151-152] | Derivación a aparato | Fontanería: Agua fría | 0.0561606 | 0.0002 | 0.0002 | 1.48388 | 185.555 | 2643.2 | 5.94829 | 5.31765 | 2.8 | 6.00445 | 5.31799 | 2.8 | P.B. | Planta Baja
TUB [133-134] | Planta Baja | 0.01 | 2.2 | 0.111275 | TUB [133-134] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.0001 | 0.0001 | 0.741938 | 1984.11 | 793.646 | 1.4 | 6.13499 | 0.7 | 1.4 | 6.13499 | 2.7 | P.B. | Planta Baja
TUB [38-39] | Planta Baja | 0.01 | 2.31 | 0.116839 | TUB [38-39] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0002 | 0.0002 | 1.48388 | 6938.4 | 2643.2 | 4.71628 | 4.83672 | 2.7 | 4.71628 | 4.83672 | 0.6 | P.B. | Planta Baja
TUB [24-25] | Planta Baja | 0.01 | 1.66778 | 0.0843559 | TUB [24-25] | Derivación a aparato | Fontanería: Agua fría | 1.51617 | 0.00015 | 0.00015 | 1.11291 | 3034.7 | 1601.25 | 2.50883 | -9.97501 | 2.7 | 4.025 | -9.97501 | 2.7 | P.B. | Planta Baja
TUB [41-42] | Planta Baja | 0.01 | 4.32413 | 0.218713 | TUB [41-42] | Derivación a aparato | Fontanería: Agua fría | 3.93103 | 0.00015 | 0.00015 | 1.11291 | 7868.18 | 1601.25 | 3.08605 | 1.96825 | 2.7 | 5.77396 | 4.83672 | 2.7 | P.B. | Planta Baja
TUB [17-18] | Planta Baja | 0.01 | 2.31 | 0.116839 | TUB [17-18] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 1.54983 | -8.318 | 0.6 | 1.54983 | -8.318 | 2.7 | P.B. | Planta Baja
TUB [190-191] | Planta Primera | 0.01 | 2.31 | 0.116839 | TUB [190-191] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0002 | 0.0002 | 1.48388 | 6938.4 | 2643.2 | 6.8 | 1.9 | 6.25 | 6.8 | 1.9 | 4.15 | P.P. | Planta Primera
TUB [67-68] | Planta Baja | 0.03 | 0.283711 | 0.01435 | TUB [67-68] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.257919 | 0.000165 | 0.000165 | 1.2242 | 609.318 | 1889.95 | 2.22706 | -6.92493 | 2.8 | 2.48498 | -6.92493 | 2.8 | P.B. | Planta Baja
TUB [23-24] | Planta Baja | 0.01 | 3.25743 | 0.16476 | TUB [23-24] | Derivación a aparato | Fontanería: Agua fría | 2.9613 | 0.00015 | 0.00015 | 1.11291 | 5927.22 | 1601.25 | 2.50883 | -7.0137 | 2.7 | 2.50883 | -9.97501 | 2.7 | P.B. | Planta Baja
TUB [148-149] | Planta Baja | 0.01 | 0.33 | 0.0166913 | TUB [148-149] | Derivación a aparato | Fontanería: Agua fría | 0.3 | 0.00015 | 0.00015 | 1.11291 | 600.468 | 1601.25 | 17.025 | 4.20016 | 0 | 16.725 | 4.20007 | 0 | P.B. | Planta Baja
TUB [37-38] | Planta Baja | 0.01 | 3.68488 | 0.18638 | TUB [37-38] | Derivación a aparato | Fontanería: Agua fría | 3.34989 | 0.0002 | 0.0002 | 1.48388 | 11068.1 | 2643.2 | 2.98605 | 1.96825 | 2.7 | 4.71628 | 4.83672 | 2.7 | P.B. | Planta Baja
TUB [13-14] | Planta Baja | 0.01 | 2.2 | 0.111275 | TUB [13-14] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.0001 | 0.0001 | 0.741938 | 1984.11 | 793.646 | 1.54 | -7.4 | 0.7 | 1.54 | -7.4 | 2.7 | P.B. | Planta Baja
TUB [189-190] | Planta Primera | 0.01 | 1.91203 | 0.0967098 | TUB [189-190] | Derivación a aparato | Fontanería: Agua fría | 1.73821 | 0.0002 | 0.0002 | 1.48388 | 5743.05 | 2643.2 | 6.1901 | 3.52769 | 6.25 | 6.8 | 1.9 | 6.25 | P.P. | Planta Primera
TUB [165-166] | Planta Primera | 0.01 | 2.2 | 0.111275 | TUB [165-166] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.0001 | 0.0001 | 0.741938 | 1984.11 | 793.646 | 10.6 | 3.2 | 4.25 | 10.6 | 3.2 | 6.25 | P.P. | Planta Primera
TUB [79-80] | Planta Baja | 0.03 | 2.31 | 0.116839 | TUB [79-80] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 4.51628 | 4.83672 | 0.6 | 4.51628 | 4.83672 | 2.7 | P.B. | Planta Baja
TUB [118-119] | Planta Baja | 0.03 | 2.2 | 0.111275 | TUB [118-119] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2 | 0.0001 | 0.0001 | 0.741938 | 1984.11 | 793.646 | 1.26422 | 4.99576 | 0.7 | 1.26422 | 4.99576 | 2.7 | P.B. | Planta Baja
TUB [90-91] | Planta Primera | 0.03 | 0.809538 | 0.0409461 | TUB [90-91] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.735944 | 0.00023 | 0.00017356 | 1.28771 | 1898.72 | 2063.98 | 11.2714 | 4.43537 | 6.35 | 11.2714 | 3.69942 | 6.35 | P.P. | Planta Primera
TUB [186-187] | Planta Primera | 0.01 | 1.26404 | 0.0639348 | TUB [186-187] | Derivación a aparato | Fontanería: Agua fría | 1.14913 | 0.0001 | 0.0001 | 0.741938 | 1140 | 793.646 | 6.1901 | 3.62769 | 6.25 | 6.79501 | 2.65067 | 6.25 | P.P. | Planta Primera
TUB [102-103] | Planta Primera | 0.03 | 0.0680586 | 0.00344238 | TUB [102-103] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.0618714 | 0.00023 | 0.00017356 | 1.28771 | 159.627 | 2063.98 | 6.42585 | 4.48643 | 6.35 | 6.42585 | 4.42456 | 6.35 | P.P. | Planta Primera
TUB [105-181] | Planta Primera | 0.03 | 2.2 | 0.111275 | TUB [105-181] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2 | 0.000065 | 0.000065 | 0.48226 | 947.073 | 378.829 | 6.8 | 4.4 | 4.25 | 6.8 | 4.4 | 6.25 | P.P. | Planta Primera
TUB [16-17] | Planta Baja | 0.01 | 1.65997 | 0.0839608 | TUB [16-17] | Derivación a aparato | Fontanería: Agua fría | 1.50907 | 0.0001 | 0.0001 | 0.741938 | 1497.08 | 793.646 | 2.30883 | -7.0137 | 2.7 | 1.54983 | -8.318 | 2.7 | P.B. | Planta Baja
TUB [182-183] | Planta Primera | 0.01 | 0.761599 | 0.0385214 | TUB [182-183] | Derivación a aparato | Fontanería: Agua fría | 0.692363 | 0.0001 | 0.0001 | 0.741938 | 686.864 | 793.646 | 6.1901 | 3.72769 | 6.25 | 6.8 | 3.4 | 6.25 | P.P. | Planta Primera
TUB [183-184] | Planta Primera | 0.01 | 2.2 | 0.111275 | TUB [183-184] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.0001 | 0.0001 | 0.741938 | 1984.11 | 793.646 | 6.8 | 3.4 | 4.25 | 6.8 | 3.4 | 6.25 | P.P. | Planta Primera
TUB [42-43] | Planta Baja | 0.01 | 2.31 | 0.116839 | TUB [42-43] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.00015 | 0.00015 | 1.11291 | 4203.27 | 1601.25 | 5.77501 | 4.83672 | 0.6 | 5.77396 | 4.83672 | 2.7 | P.B. | Planta Baja
TUB [178-179] | Planta Primera | 0.01 | 0.786015 | 0.0397564 | TUB [178-179] | Derivación a aparato | Fontanería: Agua fría | 0.71456 | 0.0001 | 0.0001 | 0.741938 | 708.884 | 793.646 | 6.1901 | 3.82769 | 6.25 | 6.8 | 4.2 | 6.25 | P.P. | Planta Primera
TUB [25-26] | Planta Baja | 0.01 | 2.2 | 0.111275 | TUB [25-26] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.00015 | 0.00015 | 1.11291 | 4003.12 | 1601.25 | 4.025 | -9.97501 | 2.7 | 4.025 | -9.97501 | 0.7 | P.B. | Planta Baja
TUB [76-77] | Planta Baja | 0.03 | 0.0915066 | 0.00462837 | TUB [76-77] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.0831878 | 0.0002 | 0.0002 | 1.48388 | 274.853 | 2643.2 | 2.31473 | 2.08083 | 2.8 | 2.39791 | 2.08083 | 2.8 | P.B. | Planta Baja
TUB [93-163] | Planta Primera | 0.03 | 2.2 | 0.111275 | TUB [93-163] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2 | 0.000065 | 0.000065 | 0.48226 | 947.073 | 378.829 | 10.6 | 4 | 4.25 | 10.6 | 4 | 6.25 | P.P. | Planta Primera
TUB [161-162] | Planta Primera | 0.01 | 2.2 | 0.111275 | TUB [161-162] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.0001 | 0.0001 | 0.741938 | 1984.11 | 793.646 | 10.6 | 4.2 | 4.25 | 10.6 | 4.2 | 6.25 | P.P. | Planta Primera
TUB [122-135] | Planta Baja | 0.03 | 2.2 | 0.111275 | TUB [122-135] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2 | 0.000065 | 0.000065 | 0.48226 | 947.073 | 378.829 | 1.2 | 6.13499 | 0.7 | 1.2 | 6.13499 | 2.7 | P.B. | Planta Baja
TUB [129-130] | Planta Baja | 0.01 | 1.11795 | 0.0565453 | TUB [129-130] | Derivación a aparato | Fontanería: Agua fría | 1.01631 | 0.0002 | 0.0002 | 1.48388 | 3357.9 | 2643.2 | 0.247244 | 5.60027 | 2.7 | 1.06422 | 4.99576 | 2.7 | P.B. | Planta Baja
TUB [19-20] | Planta Baja | 0.01 | 2.66984 | 0.13504 | TUB [19-20] | Derivación a aparato | Fontanería: Agua fría | 2.42713 | 0.0002 | 0.0002 | 1.48388 | 8019.25 | 2643.2 | 1.54 | -9.28 | 2.7 | 2.40883 | -7.0137 | 2.7 | P.B. | Planta Baja
TUB [96-167] | Planta Primera | 0.03 | 2.2 | 0.111275 | TUB [96-167] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2 | 0.000065 | 0.000065 | 0.48226 | 947.073 | 378.829 | 10.6 | 3 | 4.25 | 10.6 | 3 | 6.25 | P.P. | Planta Primera
TUB [20-21] | Planta Baja | 0.01 | 2.31 | 0.116839 | TUB [20-21] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0002 | 0.0002 | 1.48388 | 6938.4 | 2643.2 | 1.54 | -9.28 | 0.6 | 1.54 | -9.28 | 2.7 | P.B. | Planta Baja
TUB [187-188] | Planta Primera | 0.01 | 2.31 | 0.116839 | TUB [187-188] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 6.79501 | 2.65067 | 4.15 | 6.79501 | 2.65067 | 6.25 | P.P. | Planta Primera
TUB [169-170] | Planta Primera | 0.01 | 2.31 | 0.116839 | TUB [169-170] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 12.515 | 3.06567 | 4.15 | 12.515 | 3.06567 | 6.25 | P.P. | Planta Primera
TUB [73-74] | Planta Baja | 0.03 | 2.31 | 0.116839 | TUB [73-74] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 1.54 | -9.48 | 0.6 | 1.54 | -9.48 | 2.7 | P.B. | Planta Baja
TUB [168-169] | Planta Primera | 0.01 | 1.89627 | 0.0959125 | TUB [168-169] | Derivación a aparato | Fontanería: Agua fría | 1.72388 | 0.0001 | 0.0001 | 0.741938 | 1710.19 | 793.646 | 11.1137 | 4.06978 | 6.25 | 12.515 | 3.06567 | 6.25 | P.P. | Planta Primera
TUB [121-122] | Planta Baja | 0.03 | 1.02215 | 0.0516999 | TUB [121-122] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.929226 | 0.000065 | 0.000065 | 0.48226 | 440.022 | 378.829 | 0.400961 | 5.66065 | 2.7 | 1.2 | 6.13499 | 2.7 | P.B. | Planta Baja
TUB [98-99] | Planta Primera | 0.03 | 2.06719 | 0.104557 | TUB [98-99] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 1.87926 | 0.0001 | 0.0001 | 0.741938 | 1864.33 | 793.646 | 11.2714 | 3.29942 | 6.25 | 10.56 | 1.56 | 6.25 | P.P. | Planta Primera
TUB [111-192] | Planta Primera | 0.03 | 2.31 | 0.116839 | TUB [111-192] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 6.8 | 2.1 | 4.15 | 6.8 | 2.1 | 6.25 | P.P. | Planta Primera
TUB [72-73] | Planta Baja | 0.03 | 3.12647 | 0.158136 | TUB [72-73] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2.84225 | 0.0001 | 0.0001 | 0.741938 | 2819.67 | 793.646 | 2.78498 | -6.92493 | 2.7 | 1.54 | -9.48 | 2.7 | P.B. | Planta Baja
TUB [171-172] | Planta Primera | 0.01 | 2.50591 | 0.126748 | TUB [171-172] | Derivación a aparato | Fontanería: Agua fría | 2.2781 | 0.0002 | 0.0002 | 1.48388 | 7526.85 | 2643.2 | 11.1137 | 3.96978 | 6.25 | 10.56 | 1.76 | 6.25 | P.P. | Planta Primera
TUB [117-118] | Planta Baja | 0.03 | 1.13483 | 0.0573993 | TUB [117-118] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 1.03166 | 0.0001 | 0.0001 | 0.741938 | 1023.47 | 793.646 | 0.400961 | 5.56065 | 2.7 | 1.26422 | 4.99576 | 2.7 | P.B. | Planta Baja
TUB [95-96] | Planta Primera | 0.03 | 0.859307 | 0.0434634 | TUB [95-96] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.781188 | 0.000065 | 0.000065 | 0.48226 | 369.921 | 378.829 | 11.2714 | 3.39942 | 6.25 | 10.6 | 3 | 6.25 | P.P. | Planta Primera
TUB [110-111] | Planta Primera | 0.03 | 2.15665 | 0.109082 | TUB [110-111] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 1.96059 | 0.0001 | 0.0001 | 0.741938 | 1945.02 | 793.646 | 6.42585 | 4.02456 | 6.25 | 6.8 | 2.1 | 6.25 | P.P. | Planta Primera
TUB [69-70] | Planta Baja | 0.03 | 1.46209 | 0.073952 | TUB [69-70] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 1.32917 | 0.000065 | 0.000065 | 0.48226 | 629.412 | 378.829 | 2.68498 | -6.92493 | 2.7 | 1.54 | -7.6 | 2.7 | P.B. | Planta Baja
TUB [136-137] | Planta Baja | 0.01 | 0.580362 | 0.0293545 | TUB [136-137] | Derivación a aparato | Fontanería: Agua fría | 0.527602 | 0.0001 | 0.0001 | 0.741938 | 523.411 | 793.646 | 0.625 | 6.1686 | 2.7 | 0.247244 | 5.80027 | 2.7 | P.B. | Planta Baja
TUB [164-165] | Planta Primera | 0.01 | 1.2072 | 0.0610596 | TUB [164-165] | Derivación a aparato | Fontanería: Agua fría | 1.09745 | 0.0001 | 0.0001 | 0.741938 | 1088.73 | 793.646 | 11.1137 | 4.16978 | 6.25 | 10.6 | 3.2 | 6.25 | P.P. | Planta Primera
TUB [92-93] | Planta Primera | 0.03 | 0.921176 | 0.0465927 | TUB [92-93] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.837433 | 0.000065 | 0.000065 | 0.48226 | 396.555 | 378.829 | 11.2714 | 3.49942 | 6.25 | 10.6 | 4 | 6.25 | P.P. | Planta Primera
TUB [107-108] | Planta Primera | 0.03 | 0.708754 | 0.0358485 | TUB [107-108] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.644322 | 0.000065 | 0.000065 | 0.48226 | 305.11 | 378.829 | 6.42585 | 4.12456 | 6.25 | 6.8 | 3.6 | 6.25 | P.P. | Planta Primera
TUB [137-138] | Planta Baja | 0.01 | 2.31 | 0.116839 | TUB [137-138] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 0.625 | 6.1686 | 0.6 | 0.625 | 6.1686 | 2.7 | P.B. | Planta Baja
TUB [160-161] | Planta Primera | 0.01 | 0.570303 | 0.0288457 | TUB [160-161] | Derivación a aparato | Fontanería: Agua fría | 0.518457 | 0.0001 | 0.0001 | 0.741938 | 514.339 | 793.646 | 11.1137 | 4.26978 | 6.25 | 10.6 | 4.2 | 6.25 | P.P. | Planta Primera
TUB [104-105] | Planta Primera | 0.03 | 0.454571 | 0.022992 | TUB [104-105] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.413246 | 0.000065 | 0.000065 | 0.48226 | 195.687 | 378.829 | 6.42585 | 4.22456 | 6.25 | 6.8 | 4.4 | 6.25 | P.P. | Planta Primera
TUB [99-174] | Planta Primera | 0.03 | 2.31 | 0.116839 | TUB [99-174] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 10.56 | 1.56 | 4.15 | 10.56 | 1.56 | 6.25 | P.P. | Planta Primera
TUB [143-144] | Planta Baja | 0.01 | 0.235975 | 0.0119355 | TUB [143-144] | Derivación a aparato | Fontanería: Agua fría | 0.214522 | 0.0002 | 0.0002 | 1.48388 | 708.783 | 2643.2 | 15.4992 | 6.27499 | 0.7 | 15.7137 | 6.27499 | 0.7 | P.B. | Planta Baja
TUB [172-173] | Planta Primera | 0.01 | 2.31 | 0.116839 | TUB [172-173] | Derivación a aparato | Fontanería: Agua fría | 2.1 | 0.0002 | 0.0002 | 1.48388 | 6938.4 | 2643.2 | 10.56 | 1.76 | 4.15 | 10.56 | 1.76 | 6.25 | P.P. | Planta Primera
TUB [70-71] | Planta Baja | 0.03 | 2.2 | 0.111275 | TUB [70-71] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2 | 0.000065 | 0.000065 | 0.48226 | 947.073 | 378.829 | 1.54 | -7.6 | 0.7 | 1.54 | -7.6 | 2.7 | P.B. | Planta Baja
TUB [82-83] | Planta Baja | 0.03 | 2.31 | 0.116839 | TUB [82-83] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2.1 | 0.0001 | 0.0001 | 0.741938 | 2083.32 | 793.646 | 5.57501 | 4.83672 | 0.6 | 5.57501 | 4.83672 | 2.7 | P.B. | Planta Baja
TUB [152-153] | Planta Baja | 0.01 | 2.42 | 0.122403 | TUB [152-153] | Derivación a aparato | Fontanería: Agua fría | 2.2 | 0.0002 | 0.0002 | 1.48388 | 7268.8 | 2643.2 | 5.94748 | 5.31765 | 0.6 | 5.94829 | 5.31765 | 2.8 | P.B. | Planta Baja
TUB [130-131] | Planta Baja | 0.01 | 2.2 | 0.111275 | TUB [130-131] | Derivación a aparato | Fontanería: Agua fría | 2 | 0.0002 | 0.0002 | 1.48388 | 6608 | 2643.2 | 1.06422 | 4.99576 | 0.7 | 1.06422 | 4.99576 | 2.7 | P.B. | Planta Baja
TUB [81-82] | Planta Baja | 0.03 | 4.38245 | 0.221663 | TUB [81-82] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 3.98404 | 0.0001 | 0.0001 | 0.741938 | 3952.4 | 793.646 | 5.57501 | 4.83672 | 2.7 | 2.69791 | 2.08083 | 2.7 | P.B. | Planta Baja
TUB [108-185] | Planta Primera | 0.03 | 2.2 | 0.111275 | TUB [108-185] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2 | 0.000065 | 0.000065 | 0.48226 | 947.073 | 378.829 | 6.8 | 3.6 | 4.25 | 6.8 | 3.6 | 6.25 | P.P. | Planta Primera

# IfcFlowSegment: PE-X Serie 5,0-ø20 (25)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: PE-X Serie 5,0-ø20; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; NominalDiameter: 0.02 m; InnerDiameter: 0.0164 m; OuterDiameter: 0.02 m
Description: Tubería: PE-X Serie 5,0-ø20; Material: PE-X Serie 5,0
PSet_TeKton3D_Aislamiento - TK_AIS_Material: Estándar RITE; TK_AIS_Conductividad_térmica: 0.04; TK_AIS_Diámetro: 0.02 m
BaseQuantities - NetCrossSectionArea: 0.000102919 m2; GrossCrossSectionArea: 0.000314159 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Materiales plásticos; TK_ETQ_Referencia: PE-X Serie 5,0; TK_ETQ_Material: PE-X Serie 5,0; TK_ETQ_Modelo: PE-X Serie 5,0; TK_ETQ_Dimensiones: ø20; TK_ETQ_Diámetro_interior: 0.0164 m; TK_ETQ_Espesor: 0.0018 m
ICAT-Identificacio - ICAT_03-Tipus: PE-X Serie 5,0-ø20; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0018 m; ICAT-Tamany: ø20
Name | In | TK_AIS_Espesor_de_aislamiento (m) = TK_ETQ_Espesor_Aislamiento (m) | Length (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Función | TK_ETQ_Sistema = Group | TK_ETQ_Longitud (m) = ICAT-Longitud (m) | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa) | TK_PIPING_Pérdida_unitaria (Pa) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
TUB [61-62] | Planta Baja | 0.03 | 0.549307 | 0.034514 | TUB [61-62] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.49937 | 0.00015 | 0.00015 | 0.71009 | 344.892 | 552.523 | 5.95306 | -5.11406 | 2.8 | 5.45369 | -5.11406 | 2.8 | P.B. | Planta Baja
TUB [86-87] | Planta Primera | 0.03 | 0.10285 | 0.00646225 | TUB [86-87] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 0.0934999 | 0.00023 | 0.00017356 | 0.821624 | 83.1453 | 711.405 | 6.42576 | 4.90658 | 6.35 | 6.42576 | 5.00008 | 6.35 | P.P. | Planta Primera
TUB [86-101] | Planta Primera | 0.03 | 0.132172 | 0.00830459 | TUB [86-101] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 0.120156 | 0.00023 | 0.00017356 | 0.821624 | 106.849 | 711.405 | 6.42576 | 4.90658 | 6.35 | 6.42576 | 4.78643 | 6.35 | P.P. | Planta Primera
TUB [124-125] | Planta Baja | 0.01 | 1.38614 | 0.087094 | TUB [124-125] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 1.26013 | 0.0004 | 0.000301844 | 1.42891 | 2940.58 | 1866.84 | 1.50746 | 4.88231 | 2.8 | 0.247326 | 4.88231 | 2.8 | P.B. | Planta Baja
TUB [27-28] | Planta Baja | 0.01 | 4.4518 | 0.279715 | TUB [27-28] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 4.04709 | 0.0002 | 0.0002 | 0.946787 | 4604 | 910.086 | 5.55454 | -5.20484 | 2.8 | 1.50746 | -5.20436 | 2.8 | P.B. | Planta Baja
TUB [156-157] | Planta Primera | 0.01 | 5.41601 | 0.340298 | TUB [156-157] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 4.92364 | 0.0005 | 0.000315963 | 1.49575 | 12447.8 | 2022.54 | 6.19001 | 5.03374 | 6.35 | 11.1137 | 5.03374 | 6.35 | P.P. | Planta Primera
TUB [65-66] | Planta Baja | 0.03 | 0.402831 | 0.0253106 | TUB [65-66] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 0.36621 | 0.000165 | 0.000165 | 0.7811 | 298.309 | 651.668 | 1.56085 | -6.92501 | 2.8 | 1.92706 | -6.92501 | 2.8 | P.B. | Planta Baja
TUB [113-114] | Planta Baja | 0.03 | 0.110602 | 0.00694936 | TUB [113-114] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 0.100548 | 0.000165 | 0.000165 | 0.7811 | 81.9047 | 651.668 | 0.400849 | 4.90658 | 2.8 | 0.401043 | 5.00713 | 2.8 | P.B. | Planta Baja
TUB [87-88] | Planta Primera | 0.03 | 5.33006 | 0.334898 | TUB [87-88] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 4.84551 | 0.00023 | 0.00017356 | 0.821624 | 4308.9 | 711.405 | 6.42576 | 5.00008 | 6.35 | 11.2713 | 5.00008 | 6.35 | P.P. | Planta Primera
TUB [127-128] | Planta Baja | 0.01 | 0.0793827 | 0.00498776 | TUB [127-128] | Derivación a aparato | Fontanería: Agua fría | 0.072166 | 0.0004 | 0.000301844 | 1.42891 | 168.403 | 1866.84 | 0.247244 | 5.32811 | 2.8 | 0.247244 | 5.40027 | 2.8 | P.B. | Planta Baja
TUB [125-126] | Planta Baja | 0.01 | 0.16038 | 0.010077 | TUB [125-126] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 0.1458 | 0.0004 | 0.000301844 | 1.42891 | 340.231 | 1866.84 | 0.247326 | 4.88231 | 2.8 | 0.247326 | 5.02811 | 2.8 | P.B. | Planta Baja
TUB [33-34] | Planta Baja | 0.01 | 0.985555 | 0.0619242 | TUB [33-34] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 0.895959 | 0.00035 | 0.00035 | 1.65688 | 2710.52 | 2420.22 | 2.40342 | 1.96825 | 2.8 | 1.50746 | 1.96825 | 2.8 | P.B. | Planta Baja
TUB [29-30] | Planta Baja | 0.01 | 0.328368 | 0.020632 | TUB [29-30] | Derivación a aparato | Fontanería: Agua fría | 0.298516 | 0.0002 | 0.0002 | 0.946787 | 339.594 | 910.086 | 6.15306 | -5.20436 | 2.8 | 5.85454 | -5.20476 | 2.8 | P.B. | Planta Baja
TUB [157-158] | Planta Primera | 0.01 | 0.29036 | 0.0182439 | TUB [157-158] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 0.263964 | 0.0005 | 0.000315963 | 1.49575 | 667.346 | 2022.54 | 11.1137 | 5.03374 | 6.35 | 11.1137 | 4.76978 | 6.35 | P.P. | Planta Primera
TUB [58-75] | Planta Baja | 0.03 | 0.499264 | 0.0313697 | TUB [58-75] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 0.453877 | 0.0002 | 0.0002 | 0.946787 | 516.333 | 910.086 | 1.56085 | 2.08075 | 2.8 | 2.01473 | 2.08075 | 2.8 | P.B. | Planta Baja
TUB [176-177] | Planta Primera | 0.01 | 0.506 | 0.0317929 | TUB [176-177] | Derivación a aparato | Fontanería: Agua fría | 0.46 | 0.0005 | 0.000315963 | 1.49575 | 1162.96 | 2022.54 | 6.1901 | 4.02769 | 6.35 | 6.1901 | 4.48769 | 6.35 | P.P. | Planta Primera
TUB [88-89] | Planta Primera | 0.03 | 0.291188 | 0.0182959 | TUB [88-89] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 0.264717 | 0.00023 | 0.00017356 | 0.821624 | 235.401 | 711.405 | 11.2713 | 5.00008 | 6.35 | 11.2713 | 4.73537 | 6.35 | P.P. | Planta Primera
TUB [62-63] | Planta Baja | 0.03 | 2.42 | 0.152053 | TUB [62-63] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 2.2 | 0.00015 | 0.00015 | 0.71009 | 1519.44 | 552.523 | 5.95306 | -5.11406 | 0.6 | 5.95306 | -5.11406 | 2.8 | P.B. | Planta Baja
TUB [155-175] | Planta Primera | 0.01 | 0.104073 | 0.00653908 | TUB [155-175] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 0.0946115 | 0.0005 | 0.000315963 | 1.49575 | 239.194 | 2022.54 | 6.19001 | 4.88231 | 6.35 | 6.19001 | 4.78769 | 6.35 | P.P. | Planta Primera
TUB [63-64] | Planta Baja | 0.03 | 0.0993267 | 0.00624088 | TUB [63-64] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.090297 | 0.00015 | 0.00015 | 0.71009 | 62.3639 | 552.523 | 5.95306 | -5.20436 | 0.6 | 5.95306 | -5.11406 | 0.6 | P.B. | Planta Baja
TUB [30-31] | Planta Baja | 0.01 | 2.42 | 0.152053 | TUB [30-31] | Derivación a aparato | Fontanería: Agua fría | 2.2 | 0.0002 | 0.0002 | 0.946787 | 2502.74 | 910.086 | 6.15306 | -5.20436 | 0.6 | 6.15306 | -5.20436 | 2.8 | P.B. | Planta Baja
TUB [155-156] | Planta Primera | 0.01 | 0.166581 | 0.0104666 | TUB [155-156] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 0.151437 | 0.0005 | 0.000315963 | 1.49575 | 382.859 | 2022.54 | 6.19001 | 4.88231 | 6.35 | 6.19001 | 5.03374 | 6.35 | P.P. | Planta Primera
TUB [59-65] | Planta Baja | 0.03 | 1.99195 | 0.125158 | TUB [59-65] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 1.81086 | 0.000165 | 0.000165 | 0.7811 | 1475.1 | 651.668 | 1.56085 | -5.11414 | 2.8 | 1.56085 | -6.92501 | 2.8 | P.B. | Planta Baja
TUB [84-113] | Planta Baja | 0.03 | 1.276 | 0.0801734 | TUB [84-113] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 1.16 | 0.000165 | 0.000165 | 0.7811 | 944.919 | 651.668 | 1.56085 | 4.90658 | 2.8 | 0.400849 | 4.90658 | 2.8 | P.B. | Planta Baja
TUB [59-60] | Planta Baja | 0.03 | 3.95212 | 0.248319 | TUB [59-60] | Derivación a cuarto húmedo privado (ACS) | Fontanería: Agua caliente ida | 3.59284 | 0.00015 | 0.00015 | 0.71009 | 2481.41 | 552.523 | 5.15369 | -5.11414 | 2.8 | 1.56085 | -5.11414 | 2.8 | P.B. | Planta Baja

# IfcFlowSegment: PE-X Serie 5,0-ø25 (25)
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: PE-X Serie 5,0-ø25; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; NominalDiameter: 0.026 m; InnerDiameter: 0.0205 m; OuterDiameter: 0.0251 m
Description: Tubería: PE-X Serie 5,0-ø25; Material: PE-X Serie 5,0
PSet_TeKton3D_Aislamiento - TK_AIS_Material: Estándar RITE; TK_AIS_Conductividad_térmica: 0.04; TK_AIS_Diámetro: 0.0251 m
BaseQuantities - NetCrossSectionArea: 0.000164745 m2; GrossCrossSectionArea: 0.000494809 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Materiales plásticos; TK_ETQ_Referencia: PE-X Serie 5,0; TK_ETQ_Material: PE-X Serie 5,0; TK_ETQ_Modelo: PE-X Serie 5,0; TK_ETQ_Dimensiones: ø25; TK_ETQ_Diámetro_interior: 0.0205 m; TK_ETQ_Espesor: 0.0023 m
ICAT-Identificacio - ICAT_03-Tipus: PE-X Serie 5,0-ø25; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0023 m; ICAT-Tamany: ø25
Name | In | TK_AIS_Espesor_de_aislamiento (m) = TK_ETQ_Espesor_Aislamiento (m) | Length (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Función | TK_ETQ_Sistema = Group | TK_ETQ_Longitud (m) = ICAT-Longitud (m) | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa) | TK_PIPING_Pérdida_unitaria (Pa) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m) | TK_CON_N2z (m) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
TUB [140-141] | Planta Baja | 0.01 | 0.413553 | 0.0326103 | TUB [140-141] | Tubo de alimentación | Fontanería: Agua fría | 0.375957 | 0.00035 | 0.00035 | 1.0604 | 393.608 | 837.559 | 6.53131 | 5.31793 | 2.8 | 6.90726 | 5.31765 | 2.8 | P.B. | Planta Baja
TUB [52-53] | Planta Baja | 0.03 | 0.177171 | 0.0139707 | TUB [52-53] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.161065 | 0.00114 | 0.000412629 | 1.25015 | 224.978 | 1117.45 | 0.390033 | 4.24208 | 2.8 | 0.551098 | 4.24208 | 2.8 | P.B. | Planta Baja
TUB [54-55] | Planta Baja | 0.03 | 0.354713 | 0.0279705 | TUB [54-55] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.322466 | 0.00114 | 0.000412629 | 1.25015 | 450.426 | 1117.45 | 0.873564 | 3.64142 | 2.8 | 0.551098 | 3.64176 | 2.8 | P.B. | Planta Baja
TUB [51-52] | Planta Baja | 0.03 | 0.33 | 0.0260218 | TUB [51-52] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.3 | 0.00114 | 0.000412629 | 1.25015 | 419.046 | 1117.45 | 0.390033 | 4.24208 | 2.5 | 0.390033 | 4.24208 | 2.8 | P.B. | Planta Baja
TUB [45-46] | Planta Baja | 0.01 | 0.449521 | 0.0354465 | TUB [45-46] | Tubo de alimentación | Fontanería: Agua fría | 0.408656 | 0.00114 | 0.000412629 | 1.25015 | 570.818 | 1117.45 | 1.0988 | 3.53129 | 2.8 | 1.50746 | 3.53058 | 2.8 | P.B. | Planta Baja
TUB [58-59] | Planta Baja | 0.03 | 7.91438 | 0.62408 | TUB [58-59] | Distribuidor principal (ACS) | Fontanería: Agua caliente ida | 7.19489 | 0.000315 | 0.000237702 | 0.720172 | 3837.25 | 426.664 | 1.56085 | -5.11414 | 2.8 | 1.56085 | 2.08075 | 2.8 | P.B. | Planta Baja
TUB [143-146] | Planta Baja | 0.01 | 0.77 | 0.0607176 | TUB [143-146] | Tubo de alimentación | Fontanería: Agua fría | 0.7 | 0.00015 | 0.00015 | 0.454458 | 168.346 | 192.395 | 15.4992 | 6.27499 | 0.7 | 15.4992 | 6.27499 | 0 | P.B. | Planta Baja
TUB [53-54] | Planta Baja | 0.03 | 0.66035 | 0.0520712 | TUB [53-54] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.600318 | 0.00114 | 0.000412629 | 1.25015 | 838.536 | 1117.45 | 0.551098 | 4.24208 | 2.8 | 0.551098 | 3.64176 | 2.8 | P.B. | Planta Baja
TUB [56-57] | Planta Baja | 0.03 | 0.426014 | 0.0335929 | TUB [56-57] | Derivación a aparato (ACS) | Fontanería: Agua caliente ida | 0.387285 | 0.00114 | 0.000412629 | 1.25015 | 540.967 | 1117.45 | 1.56085 | 3.64176 | 2.8 | 1.17356 | 3.6415 | 2.8 | P.B. | Planta Baja
TUB [141-142] | Planta Baja | 0.01 | 9.50959 | 0.749869 | TUB [141-142] | Tubo de alimentación | Fontanería: Agua fría | 8.64508 | 0.00035 | 0.00035 | 1.0604 | 9050.96 | 837.559 | 6.90726 | 5.31765 | 2.8 | 15.4992 | 6.27499 | 2.8 | P.B. | Planta Baja
TUB [140-150] | Planta Baja | 0.01 | 0.249544 | 0.0196775 | TUB [140-150] | Tubo de alimentación | Fontanería: Agua fría | 0.226858 | 0.0002 | 0.0002 | 0.605944 | 89.6698 | 316.215 | 6.30445 | 5.31807 | 2.8 | 6.53131 | 5.31793 | 2.8 | P.B. | Planta Baja
TUB [57-84] | Planta Baja | 0.03 | 1.3913 | 0.10971 | TUB [57-84] | Distribuidor principal (ACS) | Fontanería: Agua caliente ida | 1.26482 | 0.000625 | 0.000278041 | 0.842386 | 886.057 | 560.431 | 1.56085 | 3.64176 | 2.8 | 1.56085 | 4.90658 | 2.8 | P.B. | Planta Baja
TUB [8-9] | Planta Baja | 0.01 | 0.0713253 | 0.00562428 | TUB [8-9] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 0.0648412 | 0.00055 | 0.000347559 | 1.05301 | 67.0594 | 827.368 | 1.50746 | -7.01237 | 2.8 | 1.57228 | -7.01379 | 2.8 | P.B. | Planta Baja
TUB [47-48] | Planta Baja | 0.01 | 0.449646 | 0.0354564 | TUB [47-48] | Derivación a aparato | Fontanería: Agua fría | 0.408769 | 0.00114 | 0.000412629 | 1.25015 | 570.976 | 1117.45 | 0.390033 | 3.53058 | 2.8 | 0.798802 | 3.5312 | 2.8 | P.B. | Planta Baja
TUB [48-49] | Planta Baja | 0.01 | 0.34265 | 0.0270193 | TUB [48-49] | Derivación a aparato | Fontanería: Agua fría | 0.3115 | 0.00114 | 0.000412629 | 1.25015 | 435.109 | 1117.45 | 0.390033 | 3.84208 | 2.8 | 0.390033 | 3.53058 | 2.8 | P.B. | Planta Baja
TUB [142-143] | Planta Baja | 0.01 | 2.31 | 0.182153 | TUB [142-143] | Tubo de alimentación | Fontanería: Agua fría | 2.1 | 0.00035 | 0.00035 | 1.0604 | 2198.59 | 837.559 | 15.4992 | 6.27499 | 2.8 | 15.4992 | 6.27499 | 0.7 | P.B. | Planta Baja
TUB [35-36] | Planta Baja | 0.01 | 0.0909017 | 0.00716796 | TUB [35-36] | Derivación a aparato | Fontanería: Agua fría | 0.0826379 | 0.00035 | 0.00035 | 1.0604 | 86.5177 | 837.559 | 2.70342 | 1.96825 | 2.8 | 2.78605 | 1.96825 | 2.8 | P.B. | Planta Baja
TUB [49-50] | Planta Baja | 0.01 | 0.33 | 0.0260218 | TUB [49-50] | Derivación a aparato | Fontanería: Agua fría | 0.3 | 0.00114 | 0.000412629 | 1.25015 | 419.046 | 1117.45 | 0.390033 | 3.84208 | 2.5 | 0.390033 | 3.84208 | 2.8 | P.B. | Planta Baja
TUB [139-154] | Planta Primera | 0.01 | 3.905 | 0.307925 | TUB [139-154] | Distribuidor principal | Fontanería: Agua fría | 3.55 | 0.001 | 0.000444866 | 1.34782 | 5658.46 | 1275.15 | 6.53131 | 4.88231 | 2.8 | 6.53131 | 4.88231 | 6.35 | P.P. | Planta Primera
TUB [10-11] | Planta Baja | 0.01 | 0.150205 | 0.0118443 | TUB [10-11] | Derivación a cuarto húmedo privado | Fontanería: Agua fría | 0.13655 | 0.00055 | 0.000347559 | 1.05301 | 141.221 | 827.368 | 1.87228 | -7.0137 | 2.8 | 2.00883 | -7.0137 | 2.8 | P.B. | Planta Baja
TUB [139-140] | Planta Baja | 0.01 | 0.479185 | 0.0377856 | TUB [139-140] | Distribuidor principal | Fontanería: Agua fría | 0.435623 | 0.00055 | 0.000415036 | 1.25744 | 614.724 | 1128.91 | 6.53131 | 4.88231 | 2.8 | 6.53131 | 5.31793 | 2.8 | P.B. | Planta Baja
TUB [57-58] | Planta Baja | 0.03 | 1.71712 | 0.135401 | TUB [57-58] | Distribuidor principal (ACS) | Fontanería: Agua caliente ida | 1.56101 | 0.000515 | 0.000287943 | 0.872386 | 1162.31 | 595.671 | 1.56085 | 2.08075 | 2.8 | 1.56085 | 3.64176 | 2.8 | P.B. | Planta Baja
TUB [85-86] | Planta Primera | 0.03 | 3.905 | 0.307925 | TUB [85-86] | Distribuidor principal (ACS) | Fontanería: Agua caliente ida | 3.55 | 0.00046 | 0.000234411 | 0.710198 | 1848.01 | 416.452 | 6.42576 | 4.90658 | 2.8 | 6.42576 | 4.90658 | 6.35 | P.P. | Planta Primera
TUB [154-155] | Planta Primera | 0.01 | 0.375424 | 0.0296037 | TUB [154-155] | Distribuidor principal | Fontanería: Agua fría | 0.341294 | 0.001 | 0.000444866 | 1.34782 | 544 | 1275.15 | 6.53131 | 4.88231 | 6.35 | 6.19001 | 4.88231 | 6.35 | P.P. | Planta Primera
TUB [84-85] | Planta Baja | 0.03 | 5.35141 | 0.42198 | TUB [84-85] | Distribuidor principal (ACS) | Fontanería: Agua caliente ida | 4.86491 | 0.00046 | 0.000234411 | 0.710198 | 2532.5 | 416.452 | 1.56085 | 4.90658 | 2.8 | 6.42576 | 4.90658 | 2.8 | P.B. | Planta Baja

# IfcFlowSegment: PE-X Serie 5,0-ø32 (2)
In: Planta Baja
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: PE-X Serie 5,0-ø32; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; NominalDiameter: 0.032 m; InnerDiameter: 0.0262 m; OuterDiameter: 0.032 m
Description: Tubería: PE-X Serie 5,0-ø32; Material: PE-X Serie 5,0; Group: Fontanería: Agua fría
PSet_TeKton3D_Aislamiento - TK_AIS_Material: Estándar RITE; TK_AIS_Conductividad_térmica: 0.04; TK_AIS_Espesor_de_aislamiento: 0.01 m; TK_AIS_Diámetro: 0.032 m
BaseQuantities - NetCrossSectionArea: 0.000265119 m2; GrossCrossSectionArea: 0.000804248 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Materiales plásticos; TK_ETQ_Referencia: PE-X Serie 5,0; TK_ETQ_Material: PE-X Serie 5,0; TK_ETQ_Modelo: PE-X Serie 5,0; TK_ETQ_Dimensiones: ø32; TK_ETQ_Función: Distribuidor principal; TK_ETQ_Sistema: Fontanería: Agua fría; TK_ETQ_Diámetro_interior: 0.0262 m; TK_ETQ_Espesor: 0.0029 m; TK_ETQ_Espesor_Aislamiento: 0.01 m
PSet_TeKton3D_CONNECTIONS - TK_CON_N1z: 2.8 m; TK_CON_N2x: 1.50746 m; TK_CON_N2y: 4.88231 m; TK_CON_N2z: 2.8 m
ICAT-Identificacio - ICAT_03-Tipus: PE-X Serie 5,0-ø32; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0029 m; ICAT-Tamany: ø32
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
Name | Length (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Longitud (m) = ICAT-Longitud (m) | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa) | TK_PIPING_Pérdida_unitaria (Pa) | TK_CON_N1x (m) | TK_CON_N1y (m)
TUB [45-124] | 1.4869 | 0.149479 | TUB [45-124] | 1.35173 | 0.00195 | 0.000685418 | 1.27134 | 1432.77 | 847.962 | 1.50746 | 3.53058
TUB [124-139] | 5.52624 | 0.555558 | TUB [124-139] | 5.02385 | 0.00155 | 0.000600564 | 1.11395 | 4220.59 | 672.089 | 6.53131 | 4.88231

# IfcFlowSegment: PE-X Serie 5,0-ø40 (6)
In: Planta Baja
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: PE-X Serie 5,0-ø40; WorkingPressure: 0 Pa; PressureRange: 0 to 0 Pa; TemperatureRange: 0 to 95 C; NominalDiameter: 0.04 m; InnerDiameter: 0.0327 m; OuterDiameter: 0.0399 m
Description: Tubería: PE-X Serie 5,0-ø40; Material: PE-X Serie 5,0; Group: Fontanería: Agua fría
PSet_TeKton3D_Aislamiento - TK_AIS_Material: Estándar RITE; TK_AIS_Conductividad_térmica: 0.04; TK_AIS_Espesor_de_aislamiento: 0.01 m; TK_AIS_Diámetro: 0.0399 m
BaseQuantities - NetCrossSectionArea: 0.000410543 m2; GrossCrossSectionArea: 0.00125036 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Materiales plásticos; TK_ETQ_Referencia: PE-X Serie 5,0; TK_ETQ_Material: PE-X Serie 5,0; TK_ETQ_Modelo: PE-X Serie 5,0; TK_ETQ_Dimensiones: ø40; TK_ETQ_Función: Distribuidor principal; TK_ETQ_Sistema: Fontanería: Agua fría; TK_ETQ_Diámetro_interior: 0.0327 m; TK_ETQ_Espesor: 0.0036 m; TK_ETQ_Espesor_Aislamiento: 0.01 m
PSet_TeKton3D_CONNECTIONS - TK_CON_N2z: 2.8 m
ICAT-Identificacio - ICAT_03-Tipus: PE-X Serie 5,0-ø40; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0036 m; ICAT-Tamany: ø40
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
Name | Length (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Longitud (m) = ICAT-Longitud (m) | TK_PIPING_Caudal_instalado (m3/s) | TK_PIPING_Caudal_simultáneo (m3/s) | TK_PIPING_Velocidad (m/s) | TK_PIPING_Pérdida (Pa) | TK_PIPING_Pérdida_unitaria (Pa) | TK_CON_N1x (m) | TK_CON_N1y (m) | TK_CON_N1z (m) | TK_CON_N2x (m) | TK_CON_N2y (m)
TUB [8-27] | 1.98881 | 0.249296 | TUB [8-27] | 1.80801 | 0.00364 | 0.000894452 | 1.06505 | 1065.65 | 471.524 | 1.50746 | -7.01237 | 2.8 | 1.50746 | -5.20436
TUB [5-6] | 0.0998131 | 0.0125115 | TUB [5-6] | 0.0907391 | 0.00419 | 0.000921399 | 1.09714 | 56.3533 | 496.837 | 1.04143 | -7.01254 | 2.8 | 1.13216 | -7.01242
TUB [4-5] | 3.08 | 0.386077 | TUB [4-5] | 2.8 | 0.00419 | 0.000921399 | 1.09714 | 1738.93 | 496.837 | 1.04143 | -7.01254 | 0 | 1.04143 | -7.01254
TUB [33-45] | 1.71856 | 0.215421 | TUB [33-45] | 1.56233 | 0.00309 | 0.000923952 | 1.10018 | 975.02 | 499.266 | 1.50746 | 1.96825 | 2.8 | 1.50746 | 3.53058
TUB [27-33] | 7.88987 | 0.988992 | TUB [27-33] | 7.17261 | 0.00344 | 0.000903831 | 1.07622 | 4305.97 | 480.268 | 1.50746 | -5.20436 | 2.8 | 1.50746 | 1.96825
TUB [7-8] | 0.0828219 | 0.0103817 | TUB [7-8] | 0.0752927 | 0.00419 | 0.000921399 | 1.09714 | 46.7603 | 496.837 | 1.43216 | -7.01234 | 2.8 | 1.50746 | -7.01237

# IfcFlowSegment: PE100 S5-ø25, TUB [146-147]
In: Planta Baja
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: PE100 S5-ø25; WorkingPressure: 1569058 Pa; PressureRange: 0 to 1569058 Pa; TemperatureRange: 0 to 95 C; NominalDiameter: 0.025 m; InnerDiameter: 0.0204 m; OuterDiameter: 0.025 m
Description: Tubería: PE100 S5-ø25; Material: UNE EN 12201:2003; Group: Fontanería: Agua fría
PSet_TeKton3D_Aislamiento - TK_AIS_Material: Estándar RITE; TK_AIS_Conductividad_térmica: 0.04; TK_AIS_Espesor_de_aislamiento: 0.01 m; TK_AIS_Diámetro: 0.0251 m
BaseQuantities - Length: 2.49939 m; OuterSurfaceArea: 0.196302 m2; NetCrossSectionArea: 0.000164023 m2; GrossCrossSectionArea: 0.000490874 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: TUB [146-147]; TK_ETQ_Marca: PE: Polietileno; TK_ETQ_Referencia: PE100 S5; TK_ETQ_Material: UNE EN 12201:2003; TK_ETQ_Modelo: Polietileno 100 Serie S5; TK_ETQ_Dimensiones: ø25; TK_ETQ_Función: Tubo de alimentación; TK_ETQ_Sistema: Fontanería: Agua fría; TK_ETQ_Longitud: 2.27217 m; TK_ETQ_Diámetro_interior: 0.0204 m; TK_ETQ_Espesor: 0.0023 m; TK_ETQ_Espesor_Aislamiento: 0.01 m
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.00015 m3/s; TK_PIPING_Caudal_simultáneo: 0.00015 m3/s; TK_PIPING_Velocidad: 0.458924 m/s; TK_PIPING_Pérdida: 565.442 Pa; TK_PIPING_Pérdida_unitaria: 199.084 Pa
PSet_TeKton3D_CONNECTIONS - TK_CON_N1x: 15.4992 m; TK_CON_N1y: 6.27499 m; TK_CON_N1z: 0 m; TK_CON_N2x: 16.425 m; TK_CON_N2y: 4.19999 m; TK_CON_N2z: 0 m
ICAT-Identificacio - ICAT_03-Tipus: PE100 S5-ø25; ICAT_04-Descripcio: TUB [146-147]; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0023 m; ICAT-Longitud: 2.27217 m; ICAT-Tamany: ø25
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowSegment: PE100 S5-ø40 (2)
In: Planta Baja
Type - ApplicableOccurrence: IfcPipeSegment
Type - Pset_PipeSegmentTypeCommon - Reference: PE100 S5-ø40; WorkingPressure: 1569058 Pa; PressureRange: 0 to 1569058 Pa; TemperatureRange: 0 to 95 C; NominalDiameter: 0.04 m; InnerDiameter: 0.0326 m; OuterDiameter: 0.04 m
Description: Tubería: PE100 S5-ø40; Material: UNE EN 12201:2003; Group: Fontanería: Agua fría
PSet_TeKton3D_Aislamiento - TK_AIS_Material: Estándar RITE; TK_AIS_Conductividad_térmica: 0.04; TK_AIS_Espesor_de_aislamiento: 0.01 m; TK_AIS_Diámetro: 0.0399 m
BaseQuantities - NetCrossSectionArea: 0.000421947 m2; GrossCrossSectionArea: 0.00125664 m2
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: PE: Polietileno; TK_ETQ_Referencia: PE100 S5; TK_ETQ_Material: UNE EN 12201:2003; TK_ETQ_Modelo: Polietileno 100 Serie S5; TK_ETQ_Dimensiones: ø40; TK_ETQ_Sistema: Fontanería: Agua fría; TK_ETQ_Diámetro_interior: 0.0326 m; TK_ETQ_Espesor: 0.0037 m; TK_ETQ_Espesor_Aislamiento: 0.01 m
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.00419 m3/s; TK_PIPING_Caudal_simultáneo: 0.000921399 m3/s; TK_PIPING_Velocidad: 1.10388 m/s; TK_PIPING_Pérdida_unitaria: 513.762 Pa
PSet_TeKton3D_CONNECTIONS - TK_CON_N1z: 0 m; TK_CON_N2z: 0 m
ICAT-Identificacio - ICAT_03-Tipus: PE100 S5-ø40; ICAT_05-EstatusObra: Obra nova
ICAT-Geometria - ICAT-Gruix: 0.0037 m; ICAT-Tamany: ø40
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja
Name | Length (m) | OuterSurfaceArea (m2) | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_ETQ_Función | TK_ETQ_Longitud (m) = ICAT-Longitud (m) | TK_PIPING_Pérdida (Pa) | TK_CON_N1x (m) = TK_CON_N2x (m) | TK_CON_N1y (m) | TK_CON_N2y (m)
TUB [3-4] | 10.3295 | 1.29804 | TUB [3-4] | Distribuidor principal | 9.39046 | 6030.58 | 1.04143 | -16.403 | -7.01254
TUB [1-2] | 1.54 | 0.193522 | TUB [1-2] | Tubo de acometida | 1.4 | 899.083 | 1.04184 | -19.403 | -18.003

# IfcFlowTerminal: Ducha-Ducha (4)
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Ducha-Ducha; Status: New; Color: .NOTKNOWN.
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Ducha; TK_ETQ_Modelo: Ducha; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0002 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Ducha-Ducha; ICAT_05-EstatusObra: Obra nova
Group: Fontanería: Agua fría
Name | In | Description | TK_ETQ_Nombre = ICAT_04-Descripcio | TK_PIPING_Caudal_simultáneo (m3/s) | ICAT-CodiLocalitzacio | ICAT-DescripcioLocalitzacio
PB1_DUC | Planta Baja | Hidromezclador: Ducha-Ducha | PB1_DUC | 0.0001 | P.B. | Planta Baja
PBEXT_DUC | Planta Baja | Aparato: Ducha-Ducha | PBEXT_DUC | 0.0002 | P.B. | Planta Baja
PP3_DUC | Planta Primera | Hidromezclador: Ducha-Ducha | PP3_DUC | 0.0001 | P.P. | Planta Primera
PP4_DUC | Planta Primera | Hidromezclador: Ducha-Ducha | PP4_DUC | 0.0001 | P.P. | Planta Primera

# IfcFlowTerminal: Fregadero doméstico-Fregadero doméstico, PBCOC_FRE
In: Planta Baja
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Fregadero doméstico-Fregadero doméstico; Status: New; Color: .NOTKNOWN.
Description: Hidromezclador: Fregadero doméstico-Fregadero doméstico; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Nombre: PBCOC_FRE; TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Fregadero doméstico; TK_ETQ_Modelo: Fregadero doméstico; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.0002 m3/s; TK_PIPING_Caudal_simultáneo: 0.0001 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Fregadero doméstico-Fregadero doméstico; ICAT_04-Descripcio: PBCOC_FRE; ICAT_05-EstatusObra: Obra nova
ICAT-Localitzacio - ICAT-CodiLocalitzacio: P.B.; ICAT-DescripcioLocalitzacio: Planta Baja

# IfcFlowTerminal: Grifo-Grifo aislado (2)
In: Planta Baja
Type - ApplicableOccurrence: IfcSanitaryTerminalType
Type - Pset_SanitaryTerminalTypeCommon - Reference: Grifo-Grifo aislado; Status: New; Color: .NOTKNOWN.
Description: Aparato: Grifo-Grifo aislado; Group: Fontanería: Agua fría
PSet_TeKton3D_Etiquetas - TK_ETQ_Marca: Aparatos CTE-HS4; TK_ETQ_Referencia: Grifo aislado; TK_ETQ_Modelo: Grifo aislado; TK_ETQ_Sistema: Fontanería: Agua fría
PSet_TeKton3D_PIPING - TK_PIPING_Caudal_instalado: 0.00015 m3/s; TK_PIPING_Caudal_simultáneo: 0.00015 m3/s
ICAT-Identificacio - ICAT_03-Tipus: Grifo-Grifo aislado; ICAT_05-EstatusObra: Obra nova
